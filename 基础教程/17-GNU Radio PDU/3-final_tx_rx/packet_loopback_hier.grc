options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: packet_loopback_hier
    output_language: python
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {state: disabled}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    start: '0'
    step: '0.01'
    stop: '2'
    value: '1.0'
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    comment: |-
      采用 CC Encoder 编码：
      K=7, Rate=1/2（rate = 1/Rate = 2）
      多项式使用 [109,79]

      ```
      22 e7 d5 20 -> 0010 0010 1110 0111 1101 0101 0010 0000 -> [001000] [101110] [011111] [010101] [001000] 00
      							
      	001000           001000              
      	1011011          1111001             
      	-------          -------            
      	001000           001000              
      	 000000           001000     -> 0 0 1 0 1 1     -> 000011011111 -> 0D F
      	  001000           001000     -> 0 0 1 1 1 1
      	   001000           001000
      	    000000           000000 
      	     001000           000000
      	      001000           001000
      	------           ------
      	001011     	  001111			
      ```

      note：注意，流行为应该为：Truncated，终止模式会有问题
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec
  id: variable_dummy_decoder_def
  parameters:
    comment: 虚拟编码器类，仅将输入传递到输出
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: dec
  id: variable_repetition_decoder_def
  parameters:
    comment: 重复编码
    framebits: '8000'
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {state: disabled}
- name: dec_hdr
  id: variable_dummy_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
  states: {state: disabled}
- name: dec_hdr
  id: variable_repetition_decoder_def
  parameters:
    comment: |-
      重复解码器定义
      > 重复解码器类。它采用多数投票，受 ap_prob 率影响，并决定如果 1 位数 > ap_prob，则为 1；否则为 0。
      a prior prob：某个位为 1 的先验概率（一般，除非另有说明，否则假设为 0.5）
    framebits: hdr_format.header_nbits()
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.22'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TRUNCATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: enc
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {state: disabled}
- name: enc_hdr
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: enc_hdr
  id: variable_repetition_encoder_def
  parameters:
    comment: |-
      重复编码器定义
      > 重复编码器类，将每个输入位重复多次。要解码，请对重复次数进行多数表决。
      帧位：每帧的位数。如果使用标记流样式，这是每帧允许的最大位数
      重复：重复率；编码器速率是每个输入位重复输出的位数。
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {}
- name: file_name
  id: variable
  parameters:
    comment: |-
      测试所用视频资源下载：
      https://sample-videos.com/index.php#sample-mp4-video
    value: '"a.mkv"'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Freq. Offset
    start: '-0.5'
    step: '0.0001'
    stop: '0.5'
    value: '0'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: digital.packet_utils.default_access_code
    bps: '1'
    threshold: '3'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    comment: |-
      digital.header_format_counter(access_code, threshold, bps)
      - 64 个：digital.packet_utils.default_access_code
      - 3
      - Const_PLD.bits_per_symbol()

      帧：
       | access code | hdr | payload |

      hdr：
       |  0 -- 15 | 16 -- 31 |
       | pkt len  | pkt len  |

      -> 64+2+2+payload

      ------------------------------------------------------------------
      发送数据流过程：
      x 字节输入，加上 crc32 为 x+4 字节，实施 pld_enc(enc)
      - DDD enc：相当于无 enc，数据没变
      - RED enc：rep(3) 倍重复编码，变为：3*(x+4)
      - CCED enc：一般是 2 倍，但是尾巴处会有偏差：2*(x+4)+?

      然后实施 head_format 变为：
      hdr: 64+2+2  (access code | hdr)
      payload: len(payload)

      然后对hdr 实施 enc_hdr (3 倍重复编码)

      然后分别对 hdr 和 payload 实施各自的星座调制：
      hdr：Const_HDR
      payload：Const_PLD

      然后合流后送入脉冲整形，然后送入多相任意重采样
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise Amp
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.0'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*sps
    sym_rate: '1.0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Time Offset
    start: '0.99'
    step: '0.00001'
    stop: '1.01'
    value: '1.0'
  states: {}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 5*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '"out_"+file_name'
    type: byte
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '3'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: complex
  states: {}
- name: chan_data
  id: virtual_sink
  parameters:
    stream_id: Chan Data
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass FileToPDUBlock(gr.sync_block):\n    def __init__(self, file_path=\"a.png\", pdu_length=20, sample_rate=20):\n        gr.sync_block.__init__(\n            self,\n            name=\"My File Source\",\n            in_sig=None,\n            out_sig=None\n        )\n        self.file_path = file_path\n        self.pdu_length = pdu_length\n        self.sample_rate = sample_rate\n        self.file_data = None\n        self.current_position = 0\n        \n        self.in_port_name = 'generate'\n        self.message_port_register_in(pmt.intern(self.in_port_name))\n        self.set_msg_handler(pmt.intern(self.in_port_name), self.handle_msg)\n        \n        self.out_port_name = 'pdus'\n        self.message_port_register_out(pmt.intern(self.out_port_name))\n\n        # Read file data\n        with open(self.file_path, 'rb') as file:\n            self.file_data = file.read()\n\n    def handle_msg(self, msg):\n        # Check if there is enough data left in the file\n        if self.current_position + self.pdu_length <= len(self.file_data):\n            output = np.frombuffer(self.file_data[self.current_position:self.current_position+self.pdu_length], dtype=np.uint8)\n            # print(output)\n            PMT_msg = pmt.cons(pmt.make_dict(), pmt.to_pmt(output))\n            self.message_port_pub(pmt.intern(self.out_port_name), PMT_msg)\n            self.current_position += self.pdu_length\n        \n    def work(self, input_items, output_items):\n        return 0\n\n"
    file_path: file_name
    pdu_length: '128'
    sample_rate: '128'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      1. 首先经过一个手动的 amp 幅度调节
      2. 然后送入相关性估计器，估计出最大振幅估计
      3. 然后执行所有输入乘以最大振幅估计
      4. 然后送入多相时钟同步减小 time offset 影响
      5. 然后送入head和payload解复用器
      （能根据先基于 head format 定位 header 
      （然后找出 payload 长度，进而输出 payload
      6. head 和 payload 分别实施科斯塔斯环路减小 ISI
      7. head 一路进行星座软解调，FEC 解码，头协议解析
      送入第 5 步的解复用器
      8. payload 一路进行星座软解调，转换为异步 PDU 模式，
      实施异步 FEC 解码，然后校验并去除 CRC32，
      最后输出收到的数据
    note: 接收数据流程：
  states: {}
- name: packet_rx_0
  id: packet_rx
  parameters:
    eb: eb
    hdr_const: Const_HDR
    hdr_dec: dec_hdr
    hdr_format: hdr_format
    pld_const: Const_PLD
    pld_dec: dec
    psf_taps: rx_rrc_taps
    sps: sps
  states: {}
- name: packet_tx_0
  id: packet_tx
  parameters:
    hdr_const: Const_HDR
    hdr_enc: enc_hdr
    hdr_format: hdr_format
    pld_const: Const_PLD
    pld_enc: enc
    psf_taps: tx_rrc_taps
    sps: sps
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '1000'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '20'
    minsize: '20'
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab0@2
    legend: 'False'
    size: '1024'
    tr_tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab1@2
    legend: 'False'
    size: '800'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab0@1
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab1@1
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024*2
    srate: '1'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab0@0
    label1: ''
    label2: ''
    legend: 'False'
    size: 2500*3
    srate: '1'
    tr_tag: packet_len
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: ''
    label2: ''
    legend: 'False'
    size: '1250'
    srate: '1'
    tr_delay: '50'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
    ylabel: Correlation
    ymax: '150'
    ymin: '-150'
  states: {}
- name: qtgui_time_sink_x_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab1@0
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    size: '125'
    srate: '1'
    style1: '3'
    tr_delay: '25'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"payload symbols"'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,1,1,1
    label0: Time
    label1: Freq.
    label2: Const.
    num_tabs: '3'
  states: {}
- name: tab1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,2,1,1
    label0: Time
    label1: Freq.
    label2: Const.
    num_tabs: '3'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Chan Data
  states: {}

connections:
- [blocks_message_strobe_0, strobe, epy_block_0, generate]
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', packet_rx_0, '0']
- [channels_channel_model_0, '0', chan_data, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0, pdus, blocks_message_debug_0_0_0_0, print]
- [epy_block_0, pdus, packet_tx_0, in]
- [packet_rx_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [packet_rx_0, '1', qtgui_const_sink_x_0_0_0, '0']
- [packet_rx_0, '1', qtgui_freq_sink_x_0_0, '0']
- [packet_rx_0, '1', qtgui_time_sink_x_1_0_0_1, '0']
- [packet_rx_0, pkt out, blocks_message_debug_0_0_0, print]
- [packet_rx_0, pkt out, pdu_pdu_to_stream_x_0, pdus]
- [packet_tx_0, '0', channels_channel_model_0, '0']
- [packet_tx_0, '1', qtgui_time_sink_x_0, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [pdu_random_pdu_0, pdus, packet_tx_0, in]
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
