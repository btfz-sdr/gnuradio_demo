options:
  parameters:
    category: Packet Operators
    generate_options: hb
    id: packet_tx
    output_language: python
  states: {}

blocks:
- name: filt_delay
  id: variable
  parameters:
    value: int(1+(taps_per_filt-1)//2)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: taps_per_filt
  id: variable
  parameters:
    value: len(psf_taps)/nfilts
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: hdr_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: pld_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    comment: |-
      多相任意重采样器将流的采样率提高 2 倍。
      因此，数据包长度也会增加（变为原来的两倍）。
      但数据包长度的这种变化不会传播到 PAR 块输出流中的标签。
      标记流乘以长度标签块用于更新这些标签的值。
      长度标量设置为 2，以将数据包长度更改为 packet_len*2。
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: 头+载荷合流
    lengthtagname: packet_len
    ninputs: '2'
    type: complex
  states: {}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    comment: 脉冲整形
    insert_phasing: 'True'
    length_tag_name: packet_len
    post_padding: filt_delay
    pre_padding: '0'
    type: complex
    window: firdes.window(window.WIN_HANN, 20, 0)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: hdr_const.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: pld_const.points()
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
    comment: 追加 4 字节 CRC32
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: hdr_const.pre_diff_code()
  states: {}
- name: digital_map_bb_1_0
  id: digital_map_bb
  parameters:
    map: pld_const.pre_diff_code()
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    comment: 加包头
    format: hdr_format
  states: {}
- name: fec_async_encoder_0
  id: fec_async_encoder
  parameters:
    comment: FEC 异步编码器（编码器对象，最大传输单元）
    encoder: pld_enc
    mtu: '1500'
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {}
- name: fec_async_encoder_0_0
  id: fec_async_encoder
  parameters:
    comment: 头数据也实施 FEC 编码
    encoder: hdr_enc
    mtu: '1500'
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {}
- name: hdr_const
  id: parameter
  parameters:
    label: Header constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: hdr_enc
  id: parameter
  parameters:
    label: Header FEC encoder
    value: ' fec.dummy_encoder_make(8000)'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: mod_header
  id: virtual_sink
  parameters:
    stream_id: Mod Header
  states: {}
- name: mod_payload
  id: virtual_sink
  parameters:
    stream_id: Mod Payload
  states: {}
- name: note_0
  id: note
  parameters:
    note: 头调制
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 载荷调制
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: postcrc
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: mux
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: burst
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    comment: 用作分层块（由其他块组成的块）的输入
    label: in
    type: message
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: 多项任意重采样
    nfilts: nfilts
    rrate: sps
    samp_delay: filt_delay
    taps: psf_taps
    type: ccf
  states: {}
- name: pld_const
  id: parameter
  parameters:
    label: Payload constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: pld_enc
  id: parameter
  parameters:
    label: Payload FEC encoder
    value: ' fec.dummy_encoder_make(8000)'
  states: {}
- name: psf_taps
  id: parameter
  parameters:
    label: Pulse Shape Filter
    value: '[0,]'
  states: {}
- name: rx_mod_header
  id: virtual_source
  parameters:
    stream_id: Mod Header
  states: {}
- name: rx_mod_payload
  id: virtual_source
  parameters:
    stream_id: Mod Payload
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: eng_float
    value: '2'
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', digital_map_bb_1, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_map_bb_1_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pad_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_tagged_stream_mux_0, '0', pad_sink_2, '0']
- [digital_burst_shaper_xx_0, '0', pad_sink_3, '0']
- [digital_burst_shaper_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', mod_header, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', mod_payload, '0']
- [digital_crc32_async_bb_1, out, fec_async_encoder_0, in]
- [digital_crc32_async_bb_1, out, pad_sink_1, in]
- [digital_map_bb_1, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_map_bb_1_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [digital_protocol_formatter_async_0, header, fec_async_encoder_0_0, in]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0, pdus]
- [fec_async_encoder_0, out, digital_protocol_formatter_async_0, in]
- [fec_async_encoder_0_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [pad_source_0, out, digital_crc32_async_bb_1, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_repack_bits_bb_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [rx_mod_header, '0', blocks_tagged_stream_mux_0, '0']
- [rx_mod_payload, '0', blocks_tagged_stream_mux_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
