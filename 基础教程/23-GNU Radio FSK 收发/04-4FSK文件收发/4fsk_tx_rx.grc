options:
  parameters:
    author: btfz
    generate_options: qt_gui
    id: qfsk_tx_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center
  id: variable
  parameters:
    value: 650e3
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: 150e3
  states: {}
- name: ration
  id: variable
  parameters:
    value: '50'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: sps
  states: {}
- name: rx_msg
  id: variable_qtgui_entry
  parameters:
    comment: 3,2,1,2
    gui_hint: 3,2,1,2
    label: '"收到的信息"'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '6000000'
  states: {}
- name: show_bits_num
  id: variable
  parameters:
    value: '16'
  states: {}
- name: sps
  id: variable
  parameters:
    value: (int)(samp_rate/symbol_rate)
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    comment: |-
      这是一个基于平均信号功率和阈值（单位为dB）的简单静噪模块。
      如果平均输入功率大于等于阈值，则输出等于输入功率；否则，输出为零。
      3,0,1,2
    gui_hint: 3,0,1,2
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-70'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: '10000'
    value: '10000'
  states: {}
- name: vco_max
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      对于频率偏移 Δf，输出应该是：
      output = gain * (2 * pi * Δf / samp_rate)

      # 符号0 (-1)   --- 00
      # 符号1 (-0.333)   --- 01
      # 符号2 (+0.333) --- 10
      # 符号3 (+1) --- 11
    gain: samp_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    maxoutbuf: '4096'
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_msg
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.5'
    samp_rate: samp_rate
    sensitivity: int((2 * math.pi * vco_max)/1+0.5)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[0.5, 0.6, 0.7, 0.8]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: sps-1.8
    damping: '0.707'
    loop_bw: '0.02'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: int(sps/ration)
    ted_gain: '0.05'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      """
      高性能 4FSK Slicer - 使用向量化操作
      比传统循环快10-100倍
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class vectorized_4fsk_slicer(gr.sync_block):
          """
          向量化 4FSK 切片器 - 高性能版本
          """
          def __init__(self, thresholds=[-0.75, 0, 0.75]):
              gr.sync_block.__init__(
                  self,
                  name='Vectorized 4FSK Slicer',
                  in_sig=[np.float32],
                  out_sig=[np.uint8]
              )
              
              # 转换为 numpy array 以便向量化操作
              self.thresholds = np.array(thresholds, dtype=np.float32)
              print(self.thresholds)
          
          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              t0, t1, t2 = self.thresholds
              
              # 正确的嵌套逻辑：
              out[:] = np.where(in0 < t0, 0,                # 如果 < t0 → 0
                       np.where(in0 < t1, 1,                # 否则如果 < t1 → 1
                       np.where(in0 < t2, 2, 3)))           # 否则如果 < t2 → 2，否则 → 3
              
              return len(in0)
    comment: 根据上一个输出进行切片为 0,1,2,3
    thresholds: '[-0.75, 0, 0.75]'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import struct
      import os

      class packet_sender_4fsk_final(gr.sync_block):
          def __init__(self, use_timestamp=False, idle_char=0x55, msg_repeat=5, data_repeat=2, interp=60, payload_size=36):
              gr.sync_block.__init__(self, name='4FSK Sender Final', in_sig=None, out_sig=[np.uint8])
              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              
              self.use_timestamp = use_timestamp
              self.idle_char = idle_char
              self.msg_repeat = msg_repeat
              self.data_repeat = data_repeat
              self.interp = interp
              self.payload_size = payload_size
              
              self.sn = 0
              self.payload = np.array([], dtype=np.uint8) 
              self.ptr = 0
              self.file_queue = []
              self.file_handle = None

          def _bytes_to_4fsk_symbols(self, raw_bytes):
              # 严格执行字节到 4FSK 符号的映射
              raw_np = np.array(raw_bytes, dtype=np.uint8)
              symbols = np.zeros(len(raw_np) * 4, dtype=np.uint8)
              # MSB First 映射
              symbols[0::4] = (raw_np >> 6) & 0x03
              symbols[1::4] = (raw_np >> 4) & 0x03
              symbols[2::4] = (raw_np >> 2) & 0x03
              symbols[3::4] = (raw_np >> 0) & 0x03
              return np.repeat(symbols, self.interp)

          def _create_frame(self, content_bytes, repeat):
              # 100% 还原最初的组包逻辑
              header = [0xAA, 0xBB, self.sn & 0xFF]
              ts = list(struct.pack(">I", int(time.time()*1000) & 0xFFFFFFFF)) if self.use_timestamp else []
              length = [len(content_bytes) & 0xFF]
              body = header + ts + length + list(content_bytes)
              checksum = [sum(body) & 0xFF]
              # 物理帧：前导码 + 数据包 + 结束符
              full_packet = [self.idle_char]*40 + body + checksum + [0xFF] + [self.idle_char]*5
              
              raw_data = []
              for _ in range(repeat): raw_data.extend(full_packet)
              return self._bytes_to_4fsk_symbols(raw_data)

          def handle_msg(self, msg):
              try:
                  content = pmt.to_python(pmt.cdr(msg) if pmt.is_pair(msg) else msg)
                  if isinstance(content, str) and content.startswith("send file:"):
                      fname = content.split("send file:")[1].strip()
                      if os.path.exists(fname):
                          self.file_queue.append({'type':'msg', 'data': f"send file:{fname} size:{os.path.getsize(fname)}bytes".encode()})
                          self.file_queue.append({'type':'file', 'path': fname})
                  else:
                      # --- 核心打断逻辑：直接清除文件任务，不恢复 ---
                      if self.file_handle or self.file_queue:
                          print("!!! 4FSK: Interrupt detected. Aborting current file tasks.")
                          if self.file_handle:
                              self.file_handle.close()
                              self.file_handle = None
                          self.file_queue = [] # 彻底清空队列
                          self.payload = np.array([]) # 丢弃当前还没发完的文件碎片帧
                          self.ptr = 0
                      
                      self.file_queue.append({'type':'msg', 'data': str(content).encode()})
              except: pass

          def work(self, input_items, output_items):
              if len(self.payload) == 0 and self.file_queue:
                  task = self.file_queue[0]
                  if task['type'] == 'msg':
                      self.payload = self._create_frame(task['data'], self.msg_repeat)
                      self.sn = (self.sn + 1) % 256
                      self.file_queue.pop(0)
                  elif task['type'] == 'file':
                      if not self.file_handle: self.file_handle = open(task['path'], 'rb')
                      chunk = self.file_handle.read(self.payload_size)
                      if chunk:
                          self.payload = self._create_frame(chunk, self.data_repeat)
                          self.sn = (self.sn + 1) % 256
                      else:
                          self.file_handle.close(); self.file_handle = None
                          self.file_queue.pop(0)
              
              if len(self.payload) > 0:
                  out = output_items[0]
                  n = min(len(out), len(self.payload) - self.ptr)
                  out[:n] = self.payload[self.ptr : self.ptr + n]
                  self.ptr += n
                  if self.ptr >= len(self.payload): self.payload = np.array([]); self.ptr = 0
                  return n
              output_items[0][0] = 0
              return 1
    comment: |-
      将 Unpack / Pack /  Repeat 如果放在当前模块外面，
      从源头控制了样点生成速率，减小了由于 Repeat 等
      造成的大量的数据缓冲，这样能让输入到发出立竿见影

      +----------------+--------+-----------------------+------------------------------------------+
      |    字段名称     | 字节数 |       内容 / 值        |                   说明                   |
      +----------------+--------+-----------------------+------------------------------------------+
      | 前导码(Preamble)|   30   |   0x55 (01010101)     | 唤醒同步器，在断流后用于重建符号时钟锁      |
      +----------------+--------+-----------------------+------------------------------------------+
      | 同步头(Sync)    |   2    |   0xAA 0xBB           | 帧起始标志，用于在比特流中定位字节边界      |
      +----------------+--------+-----------------------+------------------------------------------+
      | 序列号(SN)      |   1    |   0x00 - 0xFF         | 循环计数，接收端依靠此字段进行重试包去重    |
      +----------------+--------+-----------------------+------------------------------------------+
      | 长度(Length)    |   1    |   0x00 - 0xFF         | 标识 Data 字段的实际字节数                 |
      +----------------+--------+-----------------------+------------------------------------------+
      | 数据(Data)      |  变长  |   UTF-8 字符串         | 实际传输的消息内容                        |
      +----------------+--------+-----------------------+------------------------------------------+
      | 校验和(CS)      |   1    |   Header+Data 的和     | 取累加和的低8位，用于验证数据完整性        |
      +----------------+--------+-----------------------+------------------------------------------+
      | 结束符(End)     |   1    |   0xFF                | 帧结束标志，辅助解析器判断数据包合法性      |
      +----------------+--------+-----------------------+------------------------------------------+
      | 帧间隙(Gap)     |   5+   |   0x55 (01010101)     | 确保重试包之间有物理间隔，防止接收端粘包    |
      +----------------+--------+-----------------------+------------------------------------------+
    data_repeat: '10'
    idle_char: '0x55'
    interp: repeat
    msg_repeat: '40'
    payload_size: '36'
    use_timestamp: 'True'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import struct
      import os

      class fast_packet_receiver_4fsk_final(gr.sync_block):
          def __init__(self, use_timestamp=False):
              gr.sync_block.__init__(self, name='4FSK Receiver Final', in_sig=[np.uint8], out_sig=None)
              self.message_port_register_out(pmt.intern("msg_out"))
              self.use_timestamp = use_timestamp
              self.bit_buffer = np.array([], dtype=np.uint8)
              self.last_sn = -1
              
              # 文件重组状态
              self.active_file = None
              self.bytes_remaining = 0
              self.current_filename = ""
              self.total_size = 0
              self.last_percent = -1

          def _bits_to_byte(self, bits):
              res = 0
              for b in bits: res = (res << 1) | int(b)
              return res

          def work(self, input_items, output_items):
              # 1. 拼接比特流
              self.bit_buffer = np.concatenate((self.bit_buffer, input_items[0]))
              
              # 2. 搜索同步头 0xAA 0xBB
              while len(self.bit_buffer) >= 64:
                  found_sync = False
                  for shift in range(8):
                      if len(self.bit_buffer) < shift + 16: break
                      b1 = self._bits_to_byte(self.bit_buffer[shift : shift+8])
                      b2 = self._bits_to_byte(self.bit_buffer[shift+8 : shift+16])
                      if b1 == 0xAA and b2 == 0xBB:
                          self.bit_buffer = self.bit_buffer[shift:]
                          found_sync = True
                          break
                  
                  if not found_sync:
                      self.bit_buffer = self.bit_buffer[8:]
                      continue

                  # 3. 解析长度
                  len_pos = 7 if self.use_timestamp else 3
                  if len(self.bit_buffer) < (len_pos + 1) * 8: break
                  
                  payload_len = self._bits_to_byte(self.bit_buffer[len_pos*8 : (len_pos+1)*8])
                  total_bytes = len_pos + 1 + payload_len + 2
                  
                  if len(self.bit_buffer) < total_bytes * 8: break
                  
                  # 将比特转为字节数组
                  packet_bits = self.bit_buffer[:total_bytes*8].reshape(-1, 8)
                  # 使用更稳定的手动转换确保比特序
                  packet = bytes([self._bits_to_byte(b) for b in packet_bits])
                  
                  # 4. 校验和验证
                  if packet[-1] == 0xFF and (sum(packet[:-2]) & 0xFF) == packet[-2]:
                      sn = packet[2]
                      if sn != self.last_sn:
                          data_start = len_pos + 1
                          content = packet[data_start : data_start + payload_len]
                          
                          latency = 0
                          if self.use_timestamp:
                              try:
                                  ts = struct.unpack(">I", packet[3:7])[0]
                                  latency = (int(time.time()*1000) - ts) & 0xFFFFFFFF
                              except: pass
                          
                          # 进入处理流程
                          self._process(content, sn, latency)
                          self.last_sn = sn
                      self.bit_buffer = self.bit_buffer[total_bytes*8:]
                  else:
                      self.bit_buffer = self.bit_buffer[8:]
              
              if len(self.bit_buffer) > 50000: self.bit_buffer = self.bit_buffer[-100:]
              return len(input_items[0])

          def _process(self, data, sn, latency):
              # 优先检测是否为“发送文件”指令 (使用 byte 比较防止解码失败)
              if data.startswith(b"send file:"):
                  try:
                      cmd_str = data.decode('utf-8', errors='ignore')
                      parts = cmd_str.split(" ")
                      # 提取文件名和大小
                      raw_fname = parts[1].split(":")[1]
                      fsize = int(parts[2].split(":")[1].replace("bytes",""))
                      
                      # 状态重置
                      if self.active_file: self.active_file.close()
                      self.current_filename = "recv_" + os.path.basename(raw_fname)
                      self.bytes_remaining = fsize
                      self.total_size = fsize
                      self.active_file = open(self.current_filename, "wb")
                      self.last_percent = -1
                      self._pub(f"FILE_START: {self.current_filename} ({fsize} bytes)", sn, latency)
                      return
                  except Exception as e:
                      print(f"Command Error: {e}")

              # 如果当前处于文件接收状态
              if self.active_file:
                  # 写入二进制数据
                  self.active_file.write(data)
                  self.active_file.flush() # 强制落盘
                  self.bytes_remaining -= len(data)
                  
                  # 计算进度
                  percent = int((1 - self.bytes_remaining/self.total_size)*100) if self.total_size > 0 else 0
                  if percent > self.last_percent:
                      self._pub(f"Progress: {percent}%", sn, latency)
                      self.last_percent = percent
                  
                  # 文件结束
                  if self.bytes_remaining <= 0:
                      self.active_file.close()
                      self.active_file = None
                      self._pub(f"FILE_DONE: {self.current_filename}", sn, latency)
              else:
                  # 普通消息模式
                  try:
                      msg_str = data.decode('utf-8')
                      self._pub(msg_str, sn, latency)
                  except:
                      # 如果解不出来，说明是碎片或损坏数据
                      self._pub(f"DEBUG_RAW: {data.hex()[:20]}...", sn, latency)

          def _pub(self, content, sn, latency):
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern("sn"), pmt.from_long(sn))
              meta = pmt.dict_add(meta, pmt.intern("latency_ms"), pmt.from_long(latency))
              self.message_port_pub(pmt.intern("msg_out"), pmt.cons(meta, pmt.intern(str(content))))
    use_timestamp: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center
    comment: |-
      4FSK 的四个频率分别是：0.5MHz, 0.6, 0.7, 0.8

      配置 A：下变频到零中频（Zero-IF）
      Decimation: 1           # 降低 x 倍采样率
      Taps: firdes.low_pass(
          1.0,                     # 增益
          input_samp_rate,         # 输入采样率
          200e3,                   # 截止频率（略大于150kHz）
          50e3                     # 过渡带宽
      )
      Center Frequency: 650e3  # 把650kHz下变频到0Hz
      Sample Rate: input_samp_rate

      配置 B：下变频到基带（最常用）
      Decimation: 1            # 先不抽取，或根据需求设置
      Taps: firdes.complex_band_pass(
          1.0,                     # 增益
          input_samp_rate,         # 输入采样率
          -150e3,                  # 低频截止(-150kHz，相对于中心)
          150e3,                   # 高频截止(+150kHz，相对于中心)
          50e3                     # 过渡带宽
      )
      Center Frequency: 650e3  # 关键！这是你的信号中心频率
      Sample Rate: input_samp_rate
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,200e3,50e3)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      中心频率：f_center = (500k + 800k) / 2 = 650 kHz
      频率偏移（从中心到各频点）：
          f1_offset = 500k - 650k = -150 kHz
          f2_offset = 600k - 650k = -50 kHz  
          f3_offset = 700k - 650k = +50 kHz
          f4_offset = 800k - 650k = +150 kHz
      最大频偏（fsk_deviation）：从中心到最边缘的频率距离
         fsk_deviation = 150 kHz = 150e3 Hz
      频率间隔：
        f_spacing = 100 kHz
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: msg_send
    label: input
    type: string
    value: '"发送信息（支持发送文件：send file:./a.png）"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 1,1,1,1
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,1
    name: '"TX 频谱"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 1,3,1,1
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,3,1,1
    name: '"RX 频谱"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 2,2,1,2
    gui_hint: 2,2,1,2
    label1: 3.  切片后的 bits
    label2: 2. 符号同步后
    label3: 符号同步误差
    nconnections: '3'
    size: show_bits_num
    srate: symbol_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '4'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 2,0,1,2
    gui_hint: 2,0,1,2
    label1: 1. 抽取后
    size: int(show_bits_num*(sps/ration))
    srate: int(samp_rate/ration)
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '4'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: 1,0,1,1
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,1
    name: '"TX 瀑流"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: 1,2,1,1
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,2,1,1
    name: '"RX 瀑流"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      抽取，降速，让后面处理
      不需要那么大的数据量
    decim: ration
    interp: '1'
    type: fff
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:12345
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:12345
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_quadrature_demod_cf_1, '0', rational_resampler_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_1, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0, '0', zeromq_push_sink_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_1, '0']
- [blocks_vco_f_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vco_f_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vco_f_0, '0', qtgui_waterfall_sink_x_0, '0']
- [channels_channel_model_0, '0', blocks_throttle2_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_vco_f_0, '0']
- [digital_symbol_sync_xx_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '1']
- [digital_symbol_sync_xx_0, '1', qtgui_time_sink_x_0_0, '2']
- [epy_block_0, '0', blocks_uchar_to_float_0_0, '0']
- [epy_block_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [epy_block_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [epy_block_1, msg_out, blocks_message_debug_1, print]
- [epy_block_1, msg_out, blocks_msgpair_to_var_0, inpair]
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [qtgui_edit_box_msg_0, msg, epy_block_0_0, msg_in]
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [zeromq_pull_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
