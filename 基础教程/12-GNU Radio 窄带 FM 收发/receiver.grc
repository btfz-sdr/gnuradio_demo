options:
  parameters:
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: channel_filter
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '-3000'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Sqelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.05'
    stop: '100'
    value: '0.05'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: (int)(samp_rate/rf_decim)
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    comment: |-
      sqelch
      小于阈值数据过滤块
    threshold: sq_lvl
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      带通滤波器FFT过滤器
      [-3K,3K]-200Hz(576KHz)
      3 表示抽取率，三个样本取一个，采样率会变成1/3
    decim: rf_decim
    taps: channel_filter
    type: ccc
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [fft_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [zeromq_sub_source_0, '0', fft_filter_xxx_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
