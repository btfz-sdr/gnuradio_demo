options:
  parameters:
    generate_options: qt_gui
    id: transmitter
    output_language: python
    title: transmitter
  states: {}

blocks:
- name: if_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: pl_freq
  id: variable_qtgui_chooser
  parameters:
    label: PL Tone
    labels: '["0.0", "67.0", "71.9", "74.4", "77.0", "79.7", "82.5", "85.4", "88.5", "91.5", "94.8", "97.4", "100.0", "103.5", "107.2", "110.9", "114.8", "118.8", "123.0", "127.3", "131.8", "136.5", "141.3", "146.2", "151.4", "156.7", "162.2", "167.9", "173.8", "179.9", "186.2", "192.8", "203.5", "210.7", "218.1", "225.7", "233.6", "241.8", "250.3"]'
    num_opts: '0'
    options: '[0.0, 67.0, 71.9, 74.4, 77.0, 79.7, 82.5, 85.4, 88.5, 91.5, 94.8, 97.4, 100.0, 103.5, 107.2, 110.9, 114.8, 118.8, 123.0, 127.3, 131.8, 136.5, 141.3, 146.2, 151.4, 156.7, 162.2, 167.9, 173.8, 179.9, 186.2, 192.8, 203.5, 210.7, 218.1, 225.7, 233.6, 241.8, 250.3]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Audio gain
    start: '0'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: if_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.15'
    freq: pl_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Audio gain
    const: volume
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: (int)(usrp_rate/if_rate)
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: if_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: if_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: DEBUG
    nconnections: '5'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: DEBUG2
    nconnections: '2'
    size: '1024'
    srate: '192000'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tag1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {state: disabled}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {state: disabled}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: '3'
  states: {state: disabled}
- name: virtual_sink_1_1_0
  id: virtual_sink
  parameters:
    stream_id: '4'
  states: {state: disabled}
- name: virtual_sink_1_1_1
  id: virtual_sink
  parameters:
    stream_id: '5'
  states: {state: disabled}
- name: virtual_sink_1_2
  id: virtual_sink
  parameters:
    stream_id: B1
  states: {}
- name: virtual_sink_1_2_0
  id: virtual_sink
  parameters:
    stream_id: B2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tag1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {state: disabled}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: '3'
  states: {state: disabled}
- name: virtual_source_1_2
  id: virtual_source
  parameters:
    stream_id: '4'
  states: {state: disabled}
- name: virtual_source_1_3
  id: virtual_source
  parameters:
    stream_id: '5'
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: B1
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: B2
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 576kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_nbfm_tx_0, '0', virtual_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', virtual_sink_1_1_0, '0']
- [audio_source_0, '0', band_pass_filter_0, '0']
- [audio_source_0, '0', virtual_sink_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0, '0', virtual_sink_1_0, '0']
- [blocks_add_xx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_1_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_1_1, '0']
- [blocks_repeat_0, '0', zeromq_pub_sink_0, '0']
- [low_pass_filter_0, '0', blocks_repeat_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', virtual_sink_1_2_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', virtual_sink_1_2, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_1_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_1_1, '0', qtgui_time_sink_x_0, '2']
- [virtual_source_1_2, '0', qtgui_time_sink_x_0, '3']
- [virtual_source_1_3, '0', qtgui_time_sink_x_0, '4']
- [virtual_source_2, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_2_0, '0', qtgui_time_sink_x_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
