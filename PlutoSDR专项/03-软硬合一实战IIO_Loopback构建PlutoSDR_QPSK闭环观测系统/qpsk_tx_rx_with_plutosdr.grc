options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: qpsk_tx_rx_with_plutosdr
    output_language: python
    title: qpsk_tx_rx_with_plutosdr
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    comment: |-
      QPSK 信号的带宽大约是符号速率的一倍。
      根据实际系统中的滤波器和其他因素，实际带宽可能会稍微大一些，
      但一般我们近似认为带宽为符号速率的 1 到 1.2 倍。
    value: symbol_rate*1.2
  states: {}
- name: bit_rate
  id: variable
  parameters:
    comment: 比特率（Bit Rate）：这是传输比特的速率，单位是 bits per second (bps)。
    value: 400*one_frame_data*8
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: button_msg
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: 2,2,2,2
    gui_hint: 2,2,2,2
    initPressed: 'False'
    label: '"调试/发送文件"'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: file_name
  id: variable
  parameters:
    comment: |-
      测试所用视频资源下载：
      https://sample-videos.com/index.php#sample-mp4-video
    value: '"a.png"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2e9
  states: {}
- name: gui_update_time
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: one_frame_data
  id: variable
  parameters:
    comment: len(preamble)+sn(4)*repet+(payload_data_len)*repet
    value: len(preamble)+4*repet+(payload_data_len)*repet
  states: {}
- name: output_file_name
  id: variable
  parameters:
    value: '"output_"+file_name'
  states: {}
- name: payload_data_len
  id: variable
  parameters:
    value: '36'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: preamble
  id: variable
  parameters:
    comment: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: repet
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: 2,1,1,1
    gui_hint: 2,1,1,1
    label: RX GAIN
    rangeType: int
    start: '0'
    step: '1'
    stop: '62'
    value: '32'
  states: {}
- name: samp_rate_after_constellation
  id: variable
  parameters:
    comment: |-
      通常情况下，为了满足奈奎斯特采样定理，采样率至少应该是符号速率的两倍。
      不过为了实际应用中的滤波和抗混叠，一般建议采样率为符号速率的 4 倍或更高。

      这里的星座调制采用 sps=4
    value: symbol_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: |-
      符号速率（Symbol Rate）：这是传输符号的速率，单位是 symbols per second。
      QPSK 每个符号表示 2 个比特。因此，符号速率可以通过如下公式计算：
      比特率/每符号比特数
    value: bit_rate/2
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      2,0,1,1
      控制 TX1 的衰减。范围为 0 至 89.75 dB，步长为 0.25 dB。
      注意：最大输出功率出现在衰减为 0 时。
    gui_hint: 2,0,1,1
    label: GAIN 衰减
    start: '0'
    step: '0.25'
    stop: '89.75'
    value: '5'
  states: {}
- name: variable_adaptive_algorithm
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '0.001'
    type: cma
  states: {}
- name: blocks_char_to_float_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      1字节输入，2字节输出
      一字节的低位2bit输出2字节
      LSB
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: phase_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,2,3]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: 2*3.14/100.0
    max_dev: '0.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import struct


      class blk_cal_error(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, preamble=[], payload_data_len = 36, risks = 0.3, repet = 3, file_name = 'output.wav', debug = False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='cal_error',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.preamble = preamble
              self.preamble_bits = []
              self.preamble_bits_num = 0
              self.payload_data_len = payload_data_len
              self.total_num = 0
              self.total_error_num = 0
              self.datas_0 = []
              self.datas_1 = []
              self.repet = repet
              self.header_len = 4
              self.datas_one_frame_num = (len(preamble)+(self.header_len+payload_data_len)*repet)*8
              self.debug = debug
              self.risks = risks # 比较头部信息时，出错容忍度(头部需要容错率，不然在有干扰时，头部都无法准确定位了）
              
              self.file_start = 0
              self.total_file_frame_num = 0
              self.file = open(file_name,"wb")
              
              self.file_info_bits = []
              self.file_info_len = 0
              self.file_info_crc = 0
              self.zero_wait = 0 # 基于 0 的行程编码
              
              for byte in self.preamble:
                  for i in range(7, -1, -1):
                      bit = (byte >> i) & 1
                      self.preamble_bits.append(float(bit))
              self.preamble_bits_num = len(self.preamble_bits)
              self.header_bits_num = self.header_len*repet*8
                    

          def find_preamble(self, datas):
              #print(datas[0:5])
              #print(self.preamble_bits[0:5])
              #print((datas[0]-0.5)*(self.preamble_bits[0]-0.5))

              # find preamble
              total_num = len(datas)
              #if total_num > self.preamble_bits_num*3:
              #    total_num = self.preamble_bits_num*3
                  
              for i in range(total_num - self.preamble_bits_num + 1):
                  error_num = 0
                  for j in range(self.preamble_bits_num):
                      if (datas[i+j]-0.5)*(self.preamble_bits[j]-0.5) < 0:
                          error_num = error_num + 1
                          if error_num >= self.preamble_bits_num*self.risks:
                              break
                              
                  if error_num <  self.preamble_bits_num*self.risks:
                      return i

              return -1
          
          def repet_dcode(self,datas,repet_num):
              int_datas = [int(bit) for bit in datas]
              datas_len = len(int_datas)
              if datas_len % repet_num != 0:#数据不对，不是整数倍
                  print("数据长度不对!!!")
                  exit(0)
              else:
                  o_datas_len = int(datas_len/repet_num)
                  o_datas = [0]*o_datas_len
                  for idx in range(o_datas_len):
                      zero_num = 0
                      for x in range(repet_num):
                          if int_datas[o_datas_len*x+idx] == 0:
                              zero_num += 1
                      if repet_num >= 2*zero_num:
                          o_datas[idx] = 1
                  return o_datas
                          
          def write_real_data_into_file(self, real_data_array):
              int_datas = [int(bit) for bit in real_data_array]
              int_datas_num = len(int_datas)
              #print("int_datas_num",int_datas_num)
              if int_datas_num != 0:
                  byte_data = bytearray()
                  for i in range(0,int_datas_num,8):
                      byte_value = 0
                      for j in range(8):
                          if i+j < int_datas_num:
                              byte_value <<= 1
                              byte_value |= (int_datas[i+j] & 0xFF) 
                      if byte_value == 0 and self.zero_wait == 0:
                          self.zero_wait = 1
                      elif byte_value == 0 and self.zero_wait == 1:
                          # byte_data.append(0x00)
                          self.zero_wait = 0
                      elif byte_value != 0 and self.zero_wait == 0:
                          byte_data.append(byte_value)
                      elif byte_value != 0 and self.zero_wait == 1:
                          byte_data.extend([0]*byte_value)
                          self.zero_wait = 0
                          
                  self.file.write(byte_data)
                  self.file.flush()    
                  
          def cal_error(self):
              total0_num = len(self.datas_0)
              
              # find preamble
              index_0 = self.find_preamble(self.datas_0)
              
              
              if index_0 == -1 and total0_num > 4096:
              	self.datas_0 = []
              	print(index_0,total0_num,'\n')
                      
              # have at least one frame
              if index_0 != -1:
                  if index_0 + self.datas_one_frame_num <= total0_num:                
                      header0 = self.repet_dcode(self.datas_0[index_0+self.preamble_bits_num:index_0+self.preamble_bits_num+self.header_bits_num],self.repet)
                      header_bits0 = ''.join(str(int(bit)) for bit in header0)
                      index0_sn = int(header_bits0, 2)
                      if self.debug == True:
                          print('sn:%d, in0:%d, %d, payload_datas = %d (bits)' %(index0_sn, index_0, total0_num, self.payload_data_len*8))
                      
                      # 缓存文件信息 sn == 1 的包的前 8 字节
                      if self.file_start == 1 and index0_sn == 1:
                          self.file_info_bits = np.append(self.file_info_bits,self.datas_0[index_0+self.preamble_bits_num+self.header_bits_num:index_0+self.preamble_bits_num+self.header_bits_num+8*8])
                      if self.file_start == 1 and index0_sn == 2:
                          file_info = self.repet_dcode(self.file_info_bits,int(len(self.file_info_bits)/(8*8)))
                          file_info_len_bits = ''.join(str(int(bit)) for bit in file_info[0:32])
                          file_info_crc_bits = ''.join(str(int(bit)) for bit in file_info[32:64])
                          print(file_info_len_bits,file_info_crc_bits)
                          self.file_info_len = int(file_info_len_bits, 2)
                          self.file_info_crc = int(file_info_crc_bits, 2)
                          
                      
                      if (self.file_start != 0 and index0_sn == self.file_start + 1) or (index0_sn > 10 and self.file_info_len != 0):
                          # 有些情况下会断层丢几包，此时直接补 0（这样接收文件至少看起来还正常一点）
                          if index0_sn > self.file_start + 1:
                              lose = index0_sn - self.file_start - 1
                              if lose > 0 and lose < 3:
                                  for x in range(lose):
                                      self.total_file_frame_num += 1
                                      self.write_real_data_into_file([0]*self.payload_data_len)
                                      
                          self.total_file_frame_num += 1
                          self.write_real_data_into_file(self.repet_dcode(self.datas_0[index_0+self.preamble_bits_num+self.header_bits_num:index_0+self.datas_one_frame_num],self.repet))
                          # print("total_file_frame_num:%d, file_data_len:%d, file_data_crc:0x%x" %(self.total_file_frame_num,self.file_info_len,self.file_info_crc))
                              
                      self.file_start = index0_sn

                      
                      # cut the one frame
                      self.datas_0 = self.datas_0[index_0+self.datas_one_frame_num:]
                    
                      self.cal_error()
                  
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              o_len = len(output_items[0])
              
              # buffer the input datas
              self.datas_0 = np.append(self.datas_0,input_items[0])
              
              self.cal_error()
              
              if self.file_info_len != 0:
                  output_items[0][:] = [int(((self.total_file_frame_num*self.payload_data_len)*100)/self.file_info_len)*1.0]*o_len
                  #print(o_len,self.total_file_frame_num,self.total_file_frame_num*self.payload_data_len,self.file_info_len,self.file_start)
              else:
                  output_items[0][:] = [0.0]*o_len
              
                  
              return len(output_items[0])
    debug: 'False'
    file_name: output_file_name
    payload_data_len: payload_data_len
    preamble: preamble
    repet: repet
    risks: '0.1'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # coding=utf-8
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import zlib
      import pmt


      class epb_blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, file_path="a.mkv", payload_data_len=36, preamble=[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc], n_zero_frame=3, repet=3):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                      self,
                      name='MyFileSink',   # will show up in GRC
                      in_sig=None,
                      out_sig=[np.uint8]
                      )
                      
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.in_port_name = 'test/transfer'
              self.message_port_register_in(pmt.intern(self.in_port_name))
              self.set_msg_handler(pmt.intern(self.in_port_name), self.handle_msg)
              
              self.file_data = []
              self.test_data = []
              self.current_position = 0
              self.test_current_position = 0
              self.test = 1
              
              # TEST MODE DATAS: 构建调试数据帧
              self.test_data.extend(preamble)
              self.test_data.extend([0, 0, 0, 0]*repet)
              self.test_data.extend([(x&0xFF) for x in range(payload_data_len)]*repet)
              self.test_data_len = len(self.test_data)
              
              # SEND MODE DATAS: 构建发送文件数据
              with open(file_path, 'rb') as file:
                  file_data = file.read()
                  file_data_len = len(file_data)
                  file_data_crc32 = zlib.crc32(file_data) & 0xFFFFFFFF
                  file_data_pos = 0
                  
                  # 1) 将 file_data 实施 00 的行程编码（将连续 n 个 0变为：0+连续0的个数（当个数 > 0xff）
                  tmp_data = []
                  zero_num = 0
                  for d in file_data:
                      if d == 0:
                          zero_num += 1
                          if zero_num > 0xff:
                              tmp_data.append(0x00)
                              tmp_data.append(0xff)
                              zero_num -= 0xff
                      else:
                          if zero_num == 0:
                              tmp_data.append(d) 
                          else:
                              tmp_data.append(0)
                              tmp_data.append(zero_num)
                              tmp_data.append(d) 
                              zero_num = 0

                  tmp_data_len = len(tmp_data)    
                  tmp_data_crc32 =  zlib.crc32(bytes(tmp_data)) & 0xFFFFFFFF

                  tmp_data_pos = 0

                  frame_num = 1
                  # 1) 填充头部信息（文件头部）
                  # n_zero_frame
                  # 前置空帧，用于让接收锁定文件起始位置
                  # preamble + [4bytes frame_num]*repet + [4bytes total_data_len + 4bytes total_data_crc32 + [0x55]*(payload_data_len*repet-8)]
                  for idx in range(n_zero_frame):
                      self.file_data.extend(preamble)
                      self.file_data.extend([(frame_num>>24) & 0xFF, (frame_num>>16) & 0xFF, (frame_num>>8) & 0xFF, (frame_num>>0) & 0xFF]*repet)
                      self.file_data.extend([(tmp_data_len>>24) & 0xFF, (tmp_data_len>>16) & 0xFF, (tmp_data_len>>8) & 0xFF, (tmp_data_len>>0) & 0xFF, (tmp_data_crc32>>24) & 0xFF, (tmp_data_crc32>>16) & 0xFF, (tmp_data_crc32>>8) & 0xFF, (tmp_data_crc32>>0) & 0xFF])
                      self.file_data.extend([0x55]*(payload_data_len*repet-8))

                  frame_num = 2
                  # 2) n 个 frame
                  left = tmp_data_len
                  read = 0
                  while left > 0:
                      if left >= payload_data_len:
                          self.file_data.extend(preamble)
                          self.file_data.extend([(frame_num>>24) & 0xFF, (frame_num>>16) & 0xFF, (frame_num>>8) & 0xFF, (frame_num>>0) & 0xFF]*repet)
                          self.file_data.extend(tmp_data[read:read+payload_data_len]*repet)
                          if frame_num < 10:
                              self.file_data.extend(preamble)
                              self.file_data.extend([(frame_num>>24) & 0xFF, (frame_num>>16) & 0xFF, (frame_num>>8) & 0xFF, (frame_num>>0) & 0xFF]*repet)
                              self.file_data.extend(tmp_data[read:read+payload_data_len]*repet)
                          left -= payload_data_len
                      else:# 还剩，补 0 形成 1 frame
                          self.file_data.extend(preamble)
                          self.file_data.extend([(frame_num>>24) & 0xFF, (frame_num>>16) & 0xFF, (frame_num>>8) & 0xFF, (frame_num>>0) & 0xFF]*repet)
                          # self.file_data.extend(tmp_data[read:read+left]*repet)
                          # self.file_data.extend([0]*((payload_data_len-left)*repet))
                          segment = tmp_data[read:read+left] + [0] * (payload_data_len - left)
                          self.file_data.extend(segment * repet)
                          left = 0
                     
                      frame_num += 1
                      read += payload_data_len
                      # print(f"left:{left}, frame_num:{frame_num}, read:{read}, file_data_len:{len(self.file_data)}")
                  self.file_data_len = len(self.file_data)
                  print("total file data len:%d->%d, pre_file_frame_num:%d, frame num:%d" %(tmp_data_len, self.file_data_len, n_zero_frame, frame_num))

      	# 用于接收 Toggle Button 消息，用来切换状态
          def handle_msg(self, msg):
              x = pmt.to_python(msg)[1]
              if x == 1:
                  self.test = 0
              else:
                  self.test = 1
              #print(pmt.to_python(msg)[1])
               
          def work(self, input_items, output_items):
              # Check if there is enough data left in the file
              o_len = len(output_items[0])
              #print(">>>>>",o_len)
              if self.test == 1:
                  for idx in range(0,o_len,self.test_data_len):
                      left = o_len - idx
                      if left >= self.test_data_len:
                          output_items[0][idx:idx+self.test_data_len] = (self.test_data*2)[self.test_current_position:self.test_current_position+self.test_data_len]
                          self.test_current_position += self.test_data_len
                          self.test_current_position %= self.test_data_len
                      else:
                          #print(left)
                          output_items[0][idx:idx+left] = (self.test_data*2)[self.test_current_position:self.test_current_position+left]
                          self.test_current_position += left
                          self.test_current_position %= self.test_data_len
              else:
                  left = self.file_data_len - self.current_position
                  #print(o_len,left)
                  if left >= o_len:
                      output_items[0][0:o_len] = self.file_data[self.current_position:self.current_position+o_len]
                      self.current_position += o_len
                  elif left > 0:
                      output_items[0][0:left] = self.file_data[self.current_position:self.current_position+left]
                      output_items[0][left:] = [0]*(o_len-left)
                      self.current_position += left
                      self.test = 1
                  else:
                      self.test = 1

              return len(output_items[0]) 
    comment: preamble + [4bytes frame_num]*repet + [4bytes total_data_len + 4bytes total_data_crc32 + [0x55]*(data_length*repet-8)]
    file_path: file_name
    n_zero_frame: '5'
    payload_data_len: payload_data_len
    preamble: preamble
    repet: repet
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_gain
    bandwidth: int(bandwidth)
    buffer_size: buffer_size
    comment: |-
      .
      .
      .
      .
      .
      .
      .
      .
      .
      .
      .
      .
      --------------------------------------------
      URI : 设备的 IP 地址，例如“ip:192.168.2.1”（不含引号）
      采样率 : 限制值：>= 520.833K 且 <= 61.44M。对于低于 2.083 MSPS 的值，需要加载 FIR 滤波器或将其设置为自动。
      射频带宽 : 配置发射模拟滤波器：发射基极低通滤波器和发射二级低通滤波器。限值：>= 200K 和 <= 52M
      缓冲区大小 : 内部缓冲区的大小（以采样点数为单位）。IIO 模块一次只能输入/输出一个缓冲区的采样点数。要获得最高的连续采样率，请尝试使用数百万的采样点数。
      循环 : PlutoSDR 会重复读取第一个采样缓冲区，直到程序停止。PlutoSDR IIO 模块会报告其处理完成：连接到 PlutoSDR IIO 模块的模块将不再执行，但流程图的其余部分将继续执行。
      TX1衰减（dB）: 控制 TX1 的衰减。范围为 0 至 89.75 dB，步长为 0.25 dB。注意：最大输出功率出现在衰减为 0 时。
      筛选 : 允许从文件中加载 FIR 滤波器配置。
      自动筛选 : 启用后会加载默认滤波器，从而降低采样率/基带速率。
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq)
    samplerate: int(samp_rate_after_constellation)
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(bandwidth)
    bbdc: 'True'
    buffer_size: buffer_size
    comment: |-
      采样率 : >= 520.833K 且 <= 61.44M
      射频带宽 :  >= 200K 和 <= 52M
      缓冲区大小 : 内部缓冲区的大小（以采样点数为单位）。IIO 模块一次只能输入/输出一个缓冲区的采样点数。要获得最高的连续采样率，请尝试使用数百万的采样点数。
      正交 : 真/假
      射频直流校正 : 真/假
      BB DC 校正 : 真/假
      增益模式（Rx1）: 选择以下几种模式之一：手动、慢速攻击、混合和快速攻击。对于大多数频谱感知应用，建议使用手动增益，以便准确了解信号是否存在及其相对功率。
      手动增益（Rx1）（dB）: 增益值，最大值为 71 dB，或在中心频率高于 4 GHz 时为 62 dB
      筛选 : 允许从文件中加载 FIR 滤波器配置。
      自动筛选 : 启用后会加载默认滤波器，从而降低采样率/基带速率。
    filter_source: '''Auto'''
    frequency: int(freq)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate_after_constellation)
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: process
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '100'
    min: '0'
    name: ''
    type: float
    update_time: gui_update_time
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: 7,6,1,2
    gui_hint: 7,6,1,2
    legend: 'False'
    name: '"科斯塔斯环路"'
    size: '1024'
    type: complex
    update_time: gui_update_time
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 7,0,1,2
    gui_hint: 7,0,1,2
    legend: 'False'
    name: '"原始数据"'
    size: '1024'
    type: complex
    update_time: gui_update_time
  states: {}
- name: qtgui_const_sink_x_0_0_1_0
  id: qtgui_const_sink_x
  parameters:
    comment: 7,2,1,2
    gui_hint: 7,2,1,2
    legend: 'False'
    name: '"符号同步"'
    size: '1024'
    type: complex
    update_time: gui_update_time
  states: {}
- name: qtgui_const_sink_x_0_0_2
  id: qtgui_const_sink_x
  parameters:
    comment: 7,4,1,2
    gui_hint: 7,4,1,2
    legend: 'False'
    name: '"线性均衡"'
    size: '1024'
    type: complex
    update_time: gui_update_time
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    comment: 0,4,1,4
    fc: int(freq)
    fftsize: '1024'
    gui_hint: 0,4,1,4
    legend: 'False'
    name: '"接收频谱"'
    type: complex
    update_time: gui_update_time
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: 0,2,1,2
    gui_hint: 0,2,1,2
    name: '"调制后数据"'
    size: int(one_frame_data*16*2.5)
    srate: samp_rate_after_constellation
    type: complex
    update_time: gui_update_time
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    comment: 0,0,1,2
    gui_hint: 0,0,1,2
    name: '"调制前数据"'
    size: int(one_frame_data*2.5)
    srate: int(bit_rate/8)
    type: float
    update_time: gui_update_time
    ymax: '200'
    ymin: '-200'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx_data
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: o2
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: o1
  states: {}
- name: virtual_sink_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t5
  states: {}
- name: virtual_sink_1_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: t6
  states: {}
- name: virtual_sink_1_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: t4
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx_data
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: o1
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: o2
  states: {}
- name: virtual_source_1_1_0
  id: virtual_source
  parameters:
    stream_id: t4
  states: {}
- name: virtual_source_1_2
  id: virtual_source
  parameters:
    stream_id: t5
  states: {}
- name: virtual_source_1_2_0
  id: virtual_source
  parameters:
    stream_id: t6
  states: {}

connections:
- [blocks_char_to_float_0_0_1_0, '0', qtgui_time_sink_x_1_1_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_0, '0']
- [button_msg, state, epy_block_1, test/transfer]
- [channels_channel_model_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_1_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_1_0_0_0_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_1_0_0_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', virtual_sink_1_0_0_0_0_1, '0']
- [epy_block_0, '0', process, '0']
- [epy_block_1, '0', digital_constellation_modulator_0, '0']
- [epy_block_1, '0', virtual_sink_1_0_0, '0']
- [iio_pluto_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [iio_pluto_source_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']
- [virtual_source_1, '0', qtgui_const_sink_x_0_0_0, '0']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1_0_0, '0', blocks_char_to_float_0_0_1_0, '0']
- [virtual_source_1_0_0_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_1_1_0, '0', qtgui_const_sink_x_0_0_1_0, '0']
- [virtual_source_1_2, '0', qtgui_const_sink_x_0_0_2, '0']
- [virtual_source_1_2_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
