options:
  parameters:
    author: btfz
    generate_options: qt_gui
    id: sig_ai_analy
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: all_modes
  id: variable
  parameters:
    comment: '[''BPSK'', ''QPSK'', ''8PSK'', ''QAM16'', ''QAM64'', ''PAM4'']'
    value: '[''BPSK'', ''QPSK'', ''8PSK'', ''QAM16'', ''QAM64'', ''PAM4'']'
  states: {}
- name: collected_data_dir
  id: variable
  parameters:
    value: f'/home/btfz/Desktop/bbb/train/collected_data_{int(samples_per_mod/1000)}k_item{num_items}'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: mod_selection
  id: variable_qtgui_chooser
  parameters:
    comment: 1,1,1,1
    gui_hint: 1,1,1,1
    label: 选择调制
    labels: all_modes
    num_opts: '0'
    options: '[i for i in range(len(all_modes))]'
    orient: Qt.QHBoxLayout
    type: raw
    value: '0'
    widget: radio_buttons
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_items
  id: variable
  parameters:
    value: '256'
  states: {}
- name: phase_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: predict_or_collect
  id: variable_qtgui_chooser
  parameters:
    comment: 1,0,1,1
    gui_hint: 1,0,1,1
    label: 模式选择
    label0: 推理
    label1: 采集
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samples_per_mod
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: uhd_gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      uhd gain：(0~70)
      1,2,1,1
    gui_hint: 1,2,1,1
    label: GAIN
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '35'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: |-
      B210 的输入 IQ 数据范围是 [-1.0, 1.0]
      如果你用的是 QAM64，经过 RRC 滤波器后，波形的峰值可能会超过 1.0。
      在 RRC 之后加一个 Multiply Const ，值设为 0.7 左右，留出一点余量（Headroom），
      防止信号进入 B210 的 DAC 时产生削波失真。
    const: '0.7'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: predict_or_collect
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_items
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_items
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: mod_selection
    target: mod_selection
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '0'
    loop_bw: 2*3.14/100.0
    max_dev: '0.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math

      class multi_modulator(gr.interp_block):
          def __init__(self, mod_type='BPSK', sps=4):
              # 考虑到位拆解，设置插值率。sps 为每个符号的采样点数
              self.sps = sps
              gr.interp_block.__init__(
                  self,
                  name='Universal Modulator',
                  in_sig=[np.uint8],
                  out_sig=[np.complex64],
                  interp=sps
              )
              self.mod_type = mod_type
              self.phase = 0
              
              # 预定义星座图
              self.const_bpsk = np.array([-1+0j, 1+0j], dtype=np.complex64)
              self.const_qpsk = np.array([1+1j, -1+1j, -1-1j, 1-1j], dtype=np.complex64) / np.sqrt(2)
              self.const_8psk = np.exp(1j * np.arange(0, 8) * (2 * np.pi / 8))
              self.const_pam4 = np.array([-3+0j, -1+0j, 1+0j, 3+0j], dtype=np.complex64) / 3.0
              self.const_qam16 = self._make_qam(4)
              self.const_qam64 = self._make_qam(8)

          def _make_qam(self, m):
              # 生成 QAM 星座映射
              n = np.arange(m) - (m - 1) / 2.0
              x, y = np.meshgrid(n, n)
              const = (x + 1j * y).flatten()
              return const / np.sqrt(np.mean(np.abs(const)**2))

          def set_mod_type(self, mod_type):
              self.mod_type = mod_type

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # 将 Byte 转换为 Bit 流 (0x01 -> [0, 0, 0, 0, 0, 1, 1, 0])
              bits = np.unpackbits(in0) 
              
              # --- 数字调制逻辑 ---
              if self.mod_type == 'BPSK':
                  # 每 1 位一个符号
                  # [0, 0, 0, 0, 0, 1, 1, 0] -> [0, 0, 0, 0, 0, 1, 1, 0]
                  idx = bits.astype(np.int32)
                  res = np.repeat(self.const_bpsk[idx], self.sps) 
              
              elif self.mod_type == 'QPSK':
                  # 每 2 位一个符号
                  # 这一步的作用是将一维的长比特流“揉”成每行 2 列的二维矩阵。-1 表示自动计算行数。
                  # [0, 0, 0, 0, 0, 1, 1, 0] -> [[0, 0], [0, 0],  [0, 1],  [1, 0]] 
                  b = bits.reshape(-1, 2)
                  # 这是二进制转十进制的标准做法
                  idx = b[:,0]*2 + b[:,1]
                  res = np.repeat(self.const_qpsk[idx], self.sps)

              elif self.mod_type == '8PSK':
                  # 每 3 位一个符号
                  # [0, 0, 0, 0, 0, 1, 1, 0] -> [[0, 0, 0], [0, 0, 1]]  (不是 3 的倍数进行丢弃）
                  b = bits[:len(bits)//3*3].reshape(-1, 3)
                  idx = b[:,0]*4 + b[:,1]*2 + b[:,2]
                  res = np.repeat(self.const_8psk[idx], self.sps)

              elif self.mod_type == 'QAM16':
                  b = bits[:len(bits)//4*4].reshape(-1, 4)
                  idx = b[:,0]*8 + b[:,1]*4 + b[:,2]*2 + b[:,3]
                  res = np.repeat(self.const_qam16[idx % 16], self.sps)

              elif self.mod_type == 'QAM64':
                  b = bits[:len(bits)//6*6].reshape(-1, 6)
                  # 通过位移合成 0-63 的索引
                  idx = np.zeros(len(b), dtype=np.int32)
                  for i in range(6):
                      idx += (b[:, i].astype(np.int32) << (5 - i))
                  res = np.repeat(self.const_qam64[idx], self.sps)

              elif self.mod_type == 'PAM4':
                  # 每2位一个符号
                  b = bits.reshape(-1, 2)
                  idx = b[:,0]*2 + b[:,1]
                  res = np.repeat(self.const_pam4[idx], self.sps)
              else:
                  res = np.zeros(len(in0) * self.sps, dtype=np.complex64)

              # 写入输出并处理长度对齐
              n = min(len(res), len(out))
              out[:n] = res[:n]
              return n
    mod_type: all_modes[mod_selection]
    sps: sps
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      import time

      class blk(gr.sync_block):
          def __init__(self, save_dir='', 
                       num_items=256,    # GRC 传参，支持 128, 256, 512, 1024
                       wait_time=5.0, 
                       max_samples_per_mod=10000,
                       all_modes=['BPSK', 'QPSK', '8PSK', 'QAM16', 'QAM64', 'PAM4']):
              gr.sync_block.__init__(
                  self,
                  name='AMC Universal Collector',
                  in_sig=[(np.complex64, num_items)], # 自动适配输入维度
                  out_sig=None
              )

              self.save_dir = save_dir
              self.num_items = num_items
              self.wait_time = wait_time
              self.max_samples = max_samples_per_mod
              self.all_modes = all_modes
              
              # 自动调整缓冲区大小：点数越多，缓存的样本数越少，防止占用过多内存
              # 128点时缓存200个，1024点时缓存50个
              self.buffer_size = max(50, 25600 // num_items) 

              # 初始状态设为不采集
              self.current_mod_name = self.all_modes[0]
              self.has_started = False  # 新增标志位，控制总开关
              self.is_waiting = False
              self.start_collect_time = 0
            
              self.data_buffer = [] 
              # 记录每种调制当前的文件大小，换算成样本数
              self.counts = {mode: self._sync_count(mode) for mode in all_modes}

              self.message_port_register_in(pmt.intern('mod_in'))
              self.set_msg_handler(pmt.intern('mod_in'), self.handle_mod_msg)

              if save_dir == '':
                  return
                  
              if not os.path.exists(self.save_dir):
                  os.makedirs(self.save_dir)

          def _sync_count(self, mode):
              path = os.path.join(self.save_dir, f"{mode}.bin") # 改用 .bin 存储原始二进制
              if os.path.exists(path):
                  # 自动适配：每样本字节 = 2(IQ) * num_items * 4(float32)
                  sample_bytes = 2 * self.num_items * 4
                  return os.path.getsize(path) // sample_bytes
              return 0

          def handle_mod_msg(self, msg):
              try:
                  if pmt.is_pair(msg):
                      val_pmt = pmt.cdr(msg)
                      if pmt.is_integer(val_pmt):
                          idx = pmt.to_long(val_pmt)
                          if 0 <= idx < len(self.all_modes):
                              new_mod = self.all_modes[idx]
                              if not self.has_started or new_mod != self.current_mod_name:
                                  self.flush_buffer()
                                  print(f"\n[Collector] Switch to {new_mod}. Cooling...")
                                  self.current_mod_name = new_mod
                                  self.has_started = True
                                  self.is_waiting = True
                                  self.start_collect_time = time.time() + self.wait_time
              except: pass

          def flush_buffer(self):
              if not self.data_buffer:
                  return
              
              mod_path = os.path.join(self.save_dir, f"{self.current_mod_name}.bin")
              new_data = np.array(self.data_buffer, dtype=np.float32) # [N, 2, num_items]
              
              # 使用 'ab' (append binary) 模式，这是最快的磁盘操作
              with open(mod_path, 'ab') as f:
                  f.write(new_data.tobytes())
              
              self.counts[self.current_mod_name] += len(self.data_buffer)
              print(f"磁盘同步: {self.current_mod_name} 总计 {self.counts[self.current_mod_name]}")
              self.data_buffer = []

          def work(self, input_items, output_items):
              # 如果没有收到过消息，直接丢弃输入数据并返回
              if not self.has_started:
                  return len(input_items[0])

              in_data = input_items[0]
              
              if self.is_waiting:
                  if time.time() < self.start_collect_time:
                      return len(in_data)
                  self.is_waiting = False
                  print(f"开始录制: {self.current_mod_name}")

              # 检查是否达标
              if self.counts[self.current_mod_name] >= self.max_samples:
                  return len(in_data)

              # 归一化 (L2 Norm) 
              # 将每个样本的能量缩放到 1，这对 QAM 分类至关重要
              real, imag = np.real(in_data), np.imag(in_data)
              iq = np.stack((real, imag), axis=1).astype(np.float32) # [N, 2, num_items]
              
              # --- 修改前的 L2 归一化 ---
              # norms = np.linalg.norm(iq, axis=(1, 2), keepdims=True) + 1e-12
              # iq /= norms 

              # --- 修改后的 Peak 归一化 ---
              # 计算每个样本(2, 256)中所有点的最大绝对值
              # iq.shape 为 [N, 2, num_items]
              # 我们对每个样本独立寻找最大值
              peak_vals = np.max(np.abs(iq), axis=(1, 2), keepdims=True) + 1e-12
              iq /= peak_vals

              # 存入缓冲区
              remaining = self.max_samples - self.counts[self.current_mod_name] - len(self.data_buffer)
              if remaining > 0:
                  take = min(len(iq), remaining)
                  self.data_buffer.extend(iq[:take])
              
              if len(self.data_buffer) >= self.buffer_size:
                  self.flush_buffer()

              return len(in_data)
    all_modes: all_modes
    max_samples_per_mod: samples_per_mod
    num_items: num_items
    save_dir: collected_data_dir
    wait_time: '5'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import os
      import numpy as np
      from gnuradio import gr
      import onnxruntime as ort
      import time
      from collections import Counter

      class blk(gr.sync_block):
          def __init__(self, model_path='', num_items=256, window_size=50):
              gr.sync_block.__init__(
                  self,
                  name='AMC Universal Predictor',
                  in_sig=[(np.complex64, num_items)], # 自动适配 GRC 中的 num_items
                  out_sig=None
              )
              
              # 标签顺序必须与训练时一致
              self.labels = ['8PSK', 'BPSK', 'PAM4', 'QAM16', 'QAM64', 'QPSK']

              # 1. 滑动窗口参数
              self.num_items = num_items
              self.window_size = window_size  # 窗口内积累多少个预测结果后进行一次投票
              self.vote_buffer = []
              
              self.message_port_register_out(pmt.intern('prediction'))

              # 2. 强制使用 CPU 以保证实时性，避开显卡驱动库冲突
              if model_path == '' or not os.path.exists(model_path):
                  print(f"[AMC] 路径无效: {model_path}")
                  return 
                  
              # 强制 CPU 运行，避免与 GPU 驱动冲突
              self.session = ort.InferenceSession(model_path, providers=['CPUExecutionProvider'])
              
              # 自动检测模型模式 (1D 或 2D) 
              input_meta = self.session.get_inputs()[0]
              self.model_shape = input_meta.shape
              self.model_rank = len(self.model_shape)
              
              if self.model_rank == 4:
                  self.mode = '2D'
                  self.img_size = self.model_shape[2]
                  self.iq_range = 1.2 # 需与训练一致
                  self.bins = np.linspace(-self.iq_range, self.iq_range, self.img_size + 1)
                  print(f"[AMC] 检测到 2D 模型，自动切换至星座图模式 (Size: {self.img_size})")
              else:
                  self.mode = '1D'
                  print(f"[AMC] 检测到 1D 模型，自动切换至序列模式 (Items: {self.model_shape[2]})")

          # 独立预处理函数
          @staticmethod
          def preprocess_1d(in_data):
              # 数据预处理与归一化
              real = in_data.real.astype(np.float32)
              imag = in_data.imag.astype(np.float32)
              X = np.stack((real, imag), axis=1)

              # L2 范数归一化
              # norms = np.linalg.norm(X, axis=(1, 2), keepdims=True) + 1e-12
              # X /= norms
              # Peak 归一化
              peaks = np.max(np.abs(X), axis=(1, 2), keepdims=True) + 1e-12
              X /= peaks

          @staticmethod
          def preprocess_2d(in_data, bins, iq_range):
              # 1. 矢量化获取 I 和 Q [Batch, num_items]
              r = in_data.real.astype(np.float32)
              i = in_data.imag.astype(np.float32)
              
              # 2. 矢量化峰值归一化
              # 找到每个样本的最大绝对值 [Batch, 1]
              peaks = np.max(np.abs(np.stack([r, i], axis=1)), axis=(1, 2), keepdims=True) + 1e-12
              r, i = r / peaks.squeeze(-1), i / peaks.squeeze(-1)
              
              batch_size = in_data.shape[0]
              img_size = len(bins) - 1
              
              # 3. 坐标映射：将 [-iq_range, iq_range] 映射到 [0, img_size-1]
              # 计算公式：idx = (val + iq_range) / (2 * iq_range) * (img_size - 1)
              r_idx = ((r + iq_range) / (2 * iq_range) * (img_size - 1)).astype(np.int32)
              i_idx = ((i + iq_range) / (2 * iq_range) * (img_size - 1)).astype(np.int32)
              
              # 边界修剪，防止索引越界
              r_idx = np.clip(r_idx, 0, img_size - 1)
              i_idx = np.clip(i_idx, 0, img_size - 1)
              
              # 4. 快速填充图像
              # 创建空 Batch [Batch, 1, img_size, img_size]
              hist_batch = np.zeros((batch_size, img_size, img_size), dtype=np.float32)
              
              # 利用 np.add.at 进行矢量化计数
              # 生成 Batch 索引以支持多维累加
              batch_indices = np.arange(batch_size)[:, np.newaxis]
              np.add.at(hist_batch, (batch_indices, r_idx, i_idx), 1.0)
              
              # 5. 视觉增强算子（保持不变，但改为矢量化操作）
              hist_batch = np.log1p(hist_batch)
              max_vals = np.max(hist_batch, axis=(1, 2), keepdims=True) + 1e-12
              hist_batch /= max_vals
              
              return hist_batch[:, np.newaxis, :, :].astype(np.float32)
              
          def work(self, input_items, output_items):
              in_data = input_items[0]
              if len(in_data) == 0:
                  return 0

              # 3. 性能优化：抽样推理 (只处理 30% 的数据，防止 CPU 过载导致 Overflow)
              # 根据 num_items 长度动态调整抽样率
              # 点数越多（如1024），处理开销越大，抽样率可以适当降低
              throttle = 0.1 if self.num_items > 500 else 0.2
              if np.random.rand() > throttle:
                  return len(in_data)

              try:
                  # 1. 根据模式选择预处理
                  if self.mode == '2D':
                      X = self.preprocess_2d(in_data, self.bins, self.iq_range)
                  else:
                      X = self.preprocess_1d(in_data)
                  
                  # 2. 推理
                  ort_inputs = {self.session.get_inputs()[0].name: X}
                  res = self.session.run(None, ort_inputs)[0]
                  preds = np.argmax(res, axis=1)
                  
                  # 将本次 Batch 的所有预测结果放入投票箱
                  self.vote_buffer.extend(preds.tolist())
                  
              except Exception as e:
                  print(f"Inference Error: {e}")
                  return len(in_data)

              # 4. 众数投票逻辑
              if len(self.vote_buffer) >= self.window_size:
                  # 统计频率最高的类别
                  most_common = Counter(self.vote_buffer).most_common(1)
                  if most_common:
                      final_idx, count = most_common[0]
                      mod_type = self.labels[final_idx]
                      confidence = count / len(self.vote_buffer)
                      
                      # 发送最终投票结果
                      res_str = f"Final Decision: {mod_type} (Conf: {confidence:.2%})"
                      self.message_port_pub(pmt.intern('prediction'), pmt.string_to_symbol(res_str))
                  
                  # 清空投票箱，开始下一轮统计
                  self.vote_buffer = []

              return len(in_data)
    model_path: os.path.join(collected_data_dir, 'result/amc_model.onnx')
    num_items: num_items
    window_size: '50'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: note_0
  id: note
  parameters:
    note: 推理分类
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 采集样本
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: '"rx_after_sync"'
    name: ''
    size: '1024'
    type: complex
    xmax: '6'
    xmin: '-6'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 0,1,1,1
    gui_hint: 0,1,1,1
    label1: pure_constel
    label2: tx_final
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 0,0,1,1
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    label1: pure_constel
    label2: tx_final
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 0,2,1,1
    gui_hint: 0,2,1,1
    label1: pure_constel
    label2: pure_constel
    label3: tx_final
    label4: tx_final
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '1'
    interp: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: int(samp_rate/sps)
    type: interp_fir_filter_ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: int(freq)
    gain0: uhd_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: uhd_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: TX_CONSTEL
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: constel_data
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: constel_data
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: TX_CONSTEL
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_selector_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_random_source_x_0, '0', epy_block_1, '0']
- [blocks_multiply_const_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0_0_1, '0']
- [blocks_selector_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_selector_0, '1', blocks_stream_to_vector_0_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_4, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_3, '0']
- [blocks_var_to_msg_0, msgout, epy_block_3, mod_in]
- [digital_pfb_clock_sync_xxx_0, '0', analog_agc_xx_0, '0']
- [epy_block_1, '0', root_raised_cosine_filter_0, '0']
- [epy_block_1, '0', virtual_sink_1, '0']
- [epy_block_4, prediction, blocks_message_debug_0, print]
- [root_raised_cosine_filter_0, '0', blocks_multiply_const_xx_0, '0']
- [uhd_usrp_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_1, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_1_0, '0', qtgui_const_sink_x_0_0, '1']
- [virtual_source_1_0, '0', qtgui_freq_sink_x_0_0, '1']
- [virtual_source_1_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
