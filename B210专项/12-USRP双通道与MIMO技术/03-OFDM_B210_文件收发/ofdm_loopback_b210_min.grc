options:
  parameters:
    author: btfz
    category: Custom
    copyright: beautifulzzzz.com/gnuradio
    description: 使用合成后的 ofdm 模块，实现 b210 文件收发的流程图
    generate_options: qt_gui
    id: ofdm_loopback_b210_min
    output_language: python
    title: ofdm_loopback_b210_min
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.300e9
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '96'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rx_msg
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,0,1,2
    label: '"收到的信息"'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: uhd_gain
  id: variable_qtgui_range
  parameters:
    comment: uhd gain：(0~70)
    gui_hint: 1,0,1,2
    label: GAIN
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '48'
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: rx_msg
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: '*0.05'
    const: '0.05'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Packets
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    comment: 使用此块可以阻止标签传播
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: byte
    vector: range(packet_len)
  states: {state: disabled}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import struct
      import os

      class msg_to_frame(gr.sync_block):
          def __init__(self, use_timestamp=False, idel_send=True, idle_char=0x55, msg_repeat=1, data_repeat=1, payload_size=36):
              # 初始化：无输入流，输出流为字节 (uint8)
              gr.sync_block.__init__(self, name='Message to Frame', in_sig=None, out_sig=[np.uint8])
              
              # 注册消息输入端口，用于接收上游发送的消息包 (PDU/Message)
              self.message_port_register_in(pmt.intern("msg_in"))
              self.set_msg_handler(pmt.intern("msg_in"), self.handle_msg)
              
              self.use_timestamp = use_timestamp
              self.idel_send = idel_send        # 空闲时是否发信息（有些时候使用硬件，空闲时需要发东西） 
              self.idle_char = idle_char        # 空闲时要发送的信息
              self.msg_repeat = msg_repeat      # 文本消息重复发送次数（抗干扰）
              self.data_repeat = data_repeat    # 文件块重复发送次数
              self.payload_size = payload_size  # 每个帧携带的最大原始数据字节数
              
              self.sn = 0                       # 序列号 (Sequence Number)
              self.frame_queue = []             # 存储已经打包好的完整帧 (等待 work 函数输出)
              self.file_queue = []              # 存储待处理的任务信息 (文本或文件路径)
              self.file_handle = None           # 当前正在读取的文件句柄

          def _create_frame_bytes(self, content_bytes):
              """核心方法：将原始字节封装成符合协议定义的变长帧"""
              # 1. 帧头 (3字节)：同步字节 0xAA 0xBB + 当前序列号
              header = [0xAA, 0xBB, self.sn & 0xFF]
              
              # 2. 时间戳 (可选，4字节)：使用大端序编码毫秒级时间
              ts = list(struct.pack(">I", int(time.time()*1000) & 0xFFFFFFFF)) if self.use_timestamp else []
              
              # 3. 长度字段 (1字节)：记录 Data 字段的实际长度
              content_len = len(content_bytes) & 0xFF
              length_field = [content_len]
              
              # 4. 计算校验和：对 [Header + TS + Len + Data] 求和取低8位
              body = header + ts + length_field + list(content_bytes)
              checksum = [sum(body) & 0xFF]
              
              # 5. 组合最终包：主体 + 校验位 + 帧尾 (0xFF)
              full_packet = body + checksum + [0xFF]
              return full_packet

          def handle_msg(self, msg):
              """消息端口回调函数：处理异步收到的发送指令"""
              try:
                  # 将 PMT 格式消息转为 Python 类型
                  content = pmt.to_python(pmt.cdr(msg) if pmt.is_pair(msg) else msg)
                  
                  # 关键：每次收到新任务时强制递增 SN，防止接收端因为 SN 相同而误去重
                  self.sn = (self.sn + 1) % 256
                  
                  if isinstance(content, str) and content.startswith("send file:"):
                      # 处理文件发送指令：send file:路径
                      fpath = content.split("send file:")[1].strip()
                      if os.path.exists(fpath):
                          fname = os.path.basename(fpath)
                          fsize = os.path.getsize(fpath)
                          # 任务1：构造一个包含文件名和大小的文本帧，通知接收端准备接收
                          header_cmd = f"file:{fname} size:{fsize}".encode()
                          self.file_queue.append({'type':'msg', 'data': header_cmd})
                          # 任务2：标记文件任务，后续在 work 中分块读取
                          self.file_queue.append({'type':'file', 'path': fpath})
                  else:
                      # 处理普通文本消息发送
                      self.file_queue = [] # 新消息具有抢占性，清空之前的任务
                      if self.file_handle: self.file_handle.close(); self.file_handle = None
                      self.file_queue.append({'type':'msg', 'data': str(content).encode()})
              except: pass

          def work(self, input_items, output_items):
              """流处理核心：负责将 frame_queue 中的数据搬运到 GNU Radio 输出 Buffer"""
              out = output_items[0]
              noutput = len(out)
              bytes_produced = 0

              # 只要输出缓存有空间，就持续生产数据
              while bytes_produced < noutput:
                  # 第一步：如果当前没有待发送的帧，则从任务队列中“取货”并打包
                  if not self.frame_queue:
                      if self.file_queue:
                          task = self.file_queue[0]
                          if task['type'] == 'msg':
                              # 打包文本消息任务
                              frame = self._create_frame_bytes(task['data'])
                              for _ in range(self.msg_repeat):
                                  self.frame_queue.append(list(frame))
                              self.sn = (self.sn + 1) % 256 # 任务完成后 SN 自增
                              self.file_queue.pop(0)
                          elif task['type'] == 'file':
                              # 处理文件块读取任务
                              if not self.file_handle: self.file_handle = open(task['path'], 'rb')
                              chunk = self.file_handle.read(self.payload_size)
                              if chunk:
                                  # 正常读取到文件块
                                  frame = self._create_frame_bytes(chunk)
                                  for _ in range(self.data_repeat):
                                      self.frame_queue.append(list(frame))
                                  self.sn = (self.sn + 1) % 256
                              else:
                                  # 文件读取结束，发送一个 EOF (End of File) 帧告知接收端
                                  self.frame_queue.append(list(self._create_frame_bytes(b"EOF")))
                                  self.file_handle.close(); self.file_handle = None
                                  self.file_queue.pop(0)
                      else: 
                          if self.idel_send:
                              # --- 关键：没有任务时，填充 idle_char ---
                              remaining = noutput - bytes_produced
                              # 将剩余所有空间填满 idle_char (self.idle_char 在 __init__ 中定义)
                              out[bytes_produced:noutput] = np.full(remaining, self.idle_char, dtype=np.uint8)
                              bytes_produced = noutput
                          break

                  # 第二步：将 frame_queue 中打包好的帧写入输出流
                  if self.frame_queue:
                      curr_frame = self.frame_queue[0]
                      f_len = len(curr_frame)
                      
                      # 必须保证当前 work 剩余空间足以放下“一整帧”，防止帧被切断
                      if (noutput - bytes_produced) >= f_len:
                          # 写入数据到输出 Buffer
                          out[bytes_produced : bytes_produced + f_len] = np.array(curr_frame, dtype=np.uint8)
                          
                          # 重要：在每一帧的起始字节位置打上 'packet_len' 标签
                          # 这对于后续的 OFDM 调制等 Tagged Stream 模块至关重要
                          tag_pos = self.nitems_written(0) + bytes_produced
                          self.add_item_tag(0, tag_pos, pmt.intern("packet_len"), pmt.from_long(f_len))
                          
                          bytes_produced += f_len
                          self.frame_queue.pop(0) # 该帧已发送，移出队列
                      else: 
                          # 空间不足，留到下一次 work 调用
                          break
                          
              return bytes_produced
    data_repeat: '16'
    idel_send: 'False'
    idle_char: '0x55'
    msg_repeat: '40'
    payload_size: packet_len-10
    use_timestamp: 'True'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time
      import struct
      import os

      class fast_frame_receiver(gr.sync_block):
          def __init__(self, use_timestamp=False):
              # 初始化：输入为字节流 (uint8)，无输出流（通过消息端口输出结果）
              gr.sync_block.__init__(self, name='Fast Packet Receiver', in_sig=[np.uint8], out_sig=None)
              
              # 注册消息输出端口，用于将解析后的文本或系统状态发往 UI 或 Debug 模块
              self.message_port_register_out(pmt.intern("msg_out"))
              
              self.use_timestamp = use_timestamp
              self.byte_buffer = []      # 字节缓存池，用于处理跨 work 调用的数据拼接
              self.last_sn = -1          # 上一次处理成功的序列号，用于去重
              
              # 文件接收状态管理
              self.active_file = None    # 当前打开的文件对象
              self.current_filename = "" # 当前正在接收的文件名
              self.total_size = 0        # 发送端告知的文件总大小
              self.bytes_received = 0    # 已累计收到的有效字节数
              self.last_percent = -1     # 上一次发布的进度百分比（防止重复发布相同进度）

          def work(self, input_items, output_items):
              """流处理核心：从连续字节流中切分出完整的帧"""
              in_data = input_items[0]
              # 将新到达的字节存入缓存池
              self.byte_buffer.extend(in_data.tolist())
              
              # 定义包头必读长度：Sync(2)+SN(1)+Len(1) = 4字节；若含TS则+4
              header_base = 8 if self.use_timestamp else 4
              
              # 只要缓存池数据够长，就尝试解析
              while len(self.byte_buffer) >= header_base:
                  # 1. 寻找同步头 0xAA 0xBB
                  if self.byte_buffer[0] == 0xAA and self.byte_buffer[1] == 0xBB:
                      # 2. 根据协议定位长度字段 (Payload Length)
                      len_idx = 7 if self.use_timestamp else 3
                      payload_len = self.byte_buffer[len_idx]
                      
                      # 计算该帧的总理论长度：头部 + Payload + Checksum(1) + End(1)
                      total_len = len_idx + 1 + payload_len + 2
                      
                      # 如果缓存池还没收齐这一整帧，则跳出循环等待后续数据
                      if len(self.byte_buffer) < total_len: 
                          break
                      
                      # 提取完整帧数据进行后续处理
                      packet = bytes(self.byte_buffer[:total_len])
                      
                      # 3. 协议验证：检查帧尾 (0xFF) 和 校验和 (Sum of Body)
                      if packet[-1] == 0xFF and (sum(packet[:-2]) & 0xFF) == packet[-2]:
                          self._handle_packet(packet, payload_len)
                          # 处理成功，从缓存池中移除这一帧
                          self.byte_buffer = self.byte_buffer[total_len:]
                          continue # 继续处理缓存池剩余数据
                      
                      # 校验失败：说明当前 0xAABB 可能是伪同步，丢弃当前字节继续滑动寻找
                      self.byte_buffer.pop(0)
                  else:
                      # 没找到同步头，向后滑动 1 字节
                      self.byte_buffer.pop(0)
              
              # 异常防护：如果缓存池堆积过大且无法解析（失步），清理旧数据防止内存泄漏
              if len(self.byte_buffer) > 4096: 
                  self.byte_buffer = self.byte_buffer[-512:]
                  
              return len(in_data)

          def _handle_packet(self, packet, payload_len):
              """帧去重与基础信息提取"""
              sn = packet[2]
              latency = 0
              data_start = 8 if self.use_timestamp else 4
              
              # 提取时间戳并计算时延 (Latency)
              if self.use_timestamp:
                  try:
                      ts = struct.unpack(">I", packet[3:7])[0]
                      latency = (int(time.time()*1000) - ts) & 0xFFFFFFFF
                  except: pass

              # 提取 Payload 原始数据
              content = packet[data_start : data_start + payload_len]
              
              # 序列号去重逻辑：只有当 SN 发生变化时才认为是新包（抗多径/重复接收）
              if sn != self.last_sn:
                  self._process_content(content, sn, latency)
                  self.last_sn = sn

          def _process_content(self, data, sn, latency):
              """具体业务逻辑处理：文件指令解析、文件写入或消息显示"""
              
              # 逻辑 1：识别文件头指令 (例如 "file:a.jpg size:5000")
              if data.startswith(b"file:"):
                  try:
                      info = data.decode('utf-8', errors='ignore')
                      parts = info.split(" ")
                      fname = parts[0].split(":")[1]
                      
                      # 解析总大小字段以便后续计算百分比
                      self.total_size = 0
                      for p in parts:
                          if p.startswith("size:"):
                              self.total_size = int(p.split(":")[1])
                      
                      self.current_filename = "recv_" + fname
                      self.bytes_received = 0
                      self.last_percent = -1
                      
                      # 开启新文件（若有旧文件未关闭则先关闭）
                      if self.active_file: self.active_file.close()
                      self.active_file = open(self.current_filename, "wb")
                      self._pub(f"SYS: Receiving {fname} ({self.total_size} bytes)", sn, latency)
                  except Exception as e:
                      self._pub(f"SYS_ERROR: Header parse failed {str(e)}", sn, latency)
                  return

              # 逻辑 2：识别文件结束符
              if data == b"EOF":
                  if self.active_file:
                      self.active_file.close()
                      self.active_file = None
                      self._pub(f"SYS: File {self.current_filename} saved.", sn, latency)
                      self.total_size = 0 # 重置状态
                  return

              # 逻辑 3：文件数据写入与进度显示
              if self.active_file:
                  self.active_file.write(data)
                  self.active_file.flush() # 确保数据即时写入磁盘
                  self.bytes_received += len(data)
                  
                  # 计算并发布进度百分比（仅在百分比数值变化时发布，减少消息压力）
                  if self.total_size > 0:
                      percent = int((self.bytes_received / self.total_size) * 100)
                      if percent > self.last_percent:
                          self._pub(f"Progress: {percent}%", sn, latency)
                          self.last_percent = percent
                  else:
                      self._pub(f"RX_CHUNK: {self.bytes_received} bytes", sn, latency)
              else:
                  # 逻辑 4：普通文本消息解析
                  try:
                      msg = data.decode('utf-8')
                      self._pub(msg, sn, latency)
                  except:
                      # 若无法解码为 UTF-8，则显示十六进制原始码
                      self._pub(f"HEX: {data.hex()[:20]}...", sn, latency)

          def _pub(self, content, sn, latency):
              """统一的消息发布函数：封装元数据字典并发送至消息端口"""
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern("sn"), pmt.from_long(sn))
              meta = pmt.dict_add(meta, pmt.intern("latency"), pmt.from_long(latency))
              
              # 将结果发布到 "msg_out" 端口，供下游的 Message Debug 等模块使用
              self.message_port_pub(pmt.intern("msg_out"), pmt.cons(meta, pmt.to_pmt(str(content))))
    use_timestamp: 'True'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0,1,1
    name: '"发送星座"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 5,0,1,2
    key: msg_send
    label: input
    type: string
    value: '"发送信息（支持发送文件：send file:./a.png）"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,1,1
    label1: Rx Spectrum
    name: Rx Spectrum
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 3,0,1,2
    label1: ''
    name: Rx Datas
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: int(freq)
    gain0: uhd_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: int(freq)
    gain0: uhd_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_tag_gate_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_tag_gate_0, '0', uhd_usrp_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0, '0', epy_block_1, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_1, msg_out, blocks_msgpair_to_var_0, inpair]
- [qtgui_edit_box_msg_0, msg, epy_block_0_0, msg_in]
- [uhd_usrp_source_0_0, '0', digital_ofdm_rx_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
