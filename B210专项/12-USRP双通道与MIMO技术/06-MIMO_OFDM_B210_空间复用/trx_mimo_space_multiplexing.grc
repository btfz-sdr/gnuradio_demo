options:
  parameters:
    category: Custom
    description: Example of an OFDM Transmitter
    generate_options: qt_gui
    id: rx_ofdm
    output_language: python
    run_options: run
    title: OFDM Rx
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: gui_update_period
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: max_buff_size
  id: variable
  parameters:
    value: 1024*0
  states: {}
- name: min_buff_size
  id: variable
  parameters:
    value: 1024*0
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {state: disabled}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '116'
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rrc_taps_qpsk
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {state: disabled}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: tx_a_sync2
  id: variable
  parameters:
    value: '[val if i % 2 == 0 else 0 for i, val in enumerate(sync_word2)]'
  states: {}
- name: tx_a_sync2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {state: disabled}
- name: tx_b_sync2
  id: variable
  parameters:
    value: '[val if i % 2 != 0 else 0 for i, val in enumerate(sync_word2)]'
  states: {}
- name: uhd_gain
  id: variable_qtgui_range
  parameters:
    comment: uhd gain：(0~70)
    gui_hint: 3,0,1,4
    label: GAIN
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '38'
  states: {}
- name: zero_word
  id: variable
  parameters:
    value: '[0]*fft_len'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {}
- name: analog_frequency_modulator_fc_0_0_1
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {state: disabled}
- name: analog_frequency_modulator_fc_0_2
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '-2.0/fft_len'
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '255'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '1000000'
    type: byte
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.75'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '+0.25'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '+0.5'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_2
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: fft_len+fft_len//4
    type: complex
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: fft_len
    type: int
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: fft_len
    type: int
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: '*0.05'
    const: '0.05'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: '*0.05'
    const: '0.05'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: complex
    vlen: '64'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      120->480
      每个输入的1字节包含8bits 信息，
      每个输出的1字节包含2bits的信息
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      120->480
      每个输入的1字节包含8bits 信息，
      每个输出的1字节包含2bits的信息
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_stream_to_streams_0_0
  id: blocks_stream_to_streams
  parameters:
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: '48'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_3
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: '48'
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Bytes
    type: byte
  states: {}
- name: blocks_tag_debug_1_0
  id: blocks_tag_debug
  parameters:
    comment: |-
      xxx_chan_taps/xxx_taps_h1x/xxx_taps_h2x
      Tag Debug: Rx Bytes 是对的 
      MESSAGE DEBUG PRINT 其中 xxx_chan_taps 被修改后的（后面流程图修改）
    name: Rx Bytes
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_tag_debug_1_0_0
  id: blocks_tag_debug
  parameters:
    comment: |-
      xxx_chan_taps/xxx_taps_h1x/xxx_taps_h2x
      Tag Debug: Rx Bytes 是对的 
      MESSAGE DEBUG PRINT 其中 xxx_chan_taps 被修改后的（后面流程图修改）
    name: Rx Bytes
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_tag_debug_1_0_0_0
  id: blocks_tag_debug
  parameters:
    name: Rx Bytes 1
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_tag_debug_1_0_0_0_0
  id: blocks_tag_debug
  parameters:
    name: Rx Bytes
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_tag_debug_1_0_0_0_1
  id: blocks_tag_debug
  parameters:
    name: Rx Bytes 2
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_tag_debug_1_0_0_1
  id: blocks_tag_debug
  parameters:
    comment: |-
      xxx_chan_taps/xxx_taps_h1x/xxx_taps_h2x
      Tag Debug: Rx Bytes 是对的 
      MESSAGE DEBUG PRINT 其中 xxx_chan_taps 被修改后的（后面流程图修改）
    name: Rx Bytes
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_tag_debug_1_0_1
  id: blocks_tag_debug
  parameters:
    comment: |-
      xxx_chan_taps/xxx_taps_h1x/xxx_taps_h2x
      Tag Debug: Rx Bytes 是对的 
      MESSAGE DEBUG PRINT 其中 xxx_chan_taps 被修改后的（后面流程图修改）
    name: Rx Bytes
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_tag_debug_1_1
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Bytes
    type: byte
  states: {}
- name: blocks_tag_debug_1_2
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: payload
    type: complex
    vlen: fft_len
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    comment: 使用此块可以阻止标签传播
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tag_gate_0_0_0
  id: blocks_tag_gate
  parameters:
    comment: 使用此块可以阻止标签传播
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: packet_len=448+48
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0_1
  id: blocks_tagged_stream_mux
  parameters:
    comment: packet_len=448+48
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: int
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: int
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: bpsk -> header=48
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: qpsk-> data=480
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: qpsk-> data=480
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: header_mod.base()
  states: {state: disabled}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: payload_mod.base()
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 6.28/100.0
  states: {state: disabled}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 6.28/100.0
  states: {state: disabled}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: 116+4(CRC32) = 120
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_length_tag_key
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_length_tag_key
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: 116+4(CRC32) = 120
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '4'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key
    maxoutbuf: max_buff_size
    minoutbuf: min_buff_size
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_header_payload_demux_0_0_0
  id: digital_header_payload_demux
  parameters:
    guard_interval: fft_len//4
    header_len: '4'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key
    maxoutbuf: max_buff_size
    minoutbuf: min_buff_size
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1,sync_word2,zero_word)
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (zero_word, zero_word, sync_word2,zero_word)
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0_0_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {state: disabled}
- name: digital_ofdm_frame_equalizer_vcvc_0_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {state: disabled}
- name: digital_ofdm_frame_equalizer_vcvc_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {state: disabled}
- name: digital_ofdm_frame_equalizer_vcvc_1_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {state: disabled}
- name: digital_ofdm_serializer_vcc_header
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_header_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_header_0_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {state: disabled}
- name: digital_ofdm_serializer_vcc_header_1
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {state: disabled}
- name: digital_ofdm_serializer_vcc_payload
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_serializer_vcc_payload_0
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0_0_1
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {state: disabled}
- name: digital_ofdm_sync_sc_cfb_0_2
  id: digital_ofdm_sync_sc_cfb
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {state: disabled}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_formatter.base()
    len_tag_key: length_tag_key
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: digital_packet_headerparser_b_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {}
- name: digital_packet_headerparser_b_0_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {state: disabled}
- name: digital_packet_headerparser_b_0_1
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.base()
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0_1
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '0.5'
    osps: '1'
    sps: '4'
    taps: rrc_taps_qpsk
    type: ccf
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import digital


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          
          def __init__(self, 
                       vectorSize = 64, 
                       header_mod = digital.constellation_bpsk(), 
                       payload_mod = digital.constellation_qpsk(),
                       debug = False
                       ): # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Debug OFDM Block',   # will show up in GRC
                  in_sig=[(np.complex64,vectorSize)],
                  out_sig=[(np.complex64,vectorSize)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.bpsk_points = header_mod.points()   # digital.constellation_bpsk().points()
              self.qpsk_points = payload_mod.points()  # digital.constellation_qpsk().points()
              self.debug = debug

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0] #port 0

              if self.debug == True:
                  BLACK = '\033[30m'
                  RED = '\033[31m'
                  GREEN = '\033[32m'
                  YELLOW = '\033[33m'
                  BLUE = '\033[34m'
                  MAGENTA = '\033[35m'
                  CYAN = '\033[36m'
                  WHITE = '\033[37m'
                  BG_BLACK = '\033[40m'
                  BG_RED = '\033[41m'
                  BG_GREEN = '\033[42m'
                  BG_YELLOW = '\033[43m'
                  BG_BLUE = '\033[44m'
                  BG_MAGENTA = '\033[45m'
                  BG_CYAN = '\033[46m'
                  BG_WHITE = '\033[47m'
                  RESET = '\033[0m'

                  """example: multiply with constant"""
                  print('\n-> every channel\'s datas:(%dx%d)' %(len(input_items[0][0]),len(input_items[0])))

                  for offset in range(len(input_items[0][0])):
                      if offset in [11,25,39,53]:
                          color = BG_BLACK+YELLOW
                          reset = RESET
                      elif offset in [0,1,2,3,4,5,59,60,61,62,63,32]:
                          color = BG_WHITE+RED
                          reset = RESET
                      else:
                          color = BG_GREEN+BLACK
                          reset = RESET
                 
                      print(color+"[%02d]->"  %(offset), end = ' ')
                      for vectorIndex in range(len(input_items[0])):
                          value = input_items[0][vectorIndex][offset]
                          if value in self.qpsk_points:
                              print('q%d' %(self.qpsk_points.index(value)), end = ' ')
                          elif value in self.bpsk_points:
                              print('b%d' %(self.bpsk_points.index(value)), end = ' ')
                          else:
                              if value.real < -1.4:
                                  print('x-', end = ' ')
                              elif value.real > 1.4:
                                  print('x+', end = ' ')
                              else:
                                  print('x0', end = ' ')
                      print(reset)
                  #print(len(input_items[0]),len(input_items[0][0]))

              return len(output_items[0])
    comment: debug for analy ofdm header
    debug: 'False'
    header_mod: header_mod
    payload_mod: payload_mod
    vectorSize: fft_len
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio import digital


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          
          def __init__(self, 
                       vectorSize = 64, 
                       header_mod = digital.constellation_bpsk(), 
                       payload_mod = digital.constellation_qpsk(),
                       debug = False
                       ): # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Debug OFDM Block',   # will show up in GRC
                  in_sig=[(np.complex64,vectorSize)],
                  out_sig=[(np.complex64,vectorSize)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.bpsk_points = header_mod.points()   # digital.constellation_bpsk().points()
              self.qpsk_points = payload_mod.points()  # digital.constellation_qpsk().points()
              self.debug = debug

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0] #port 0

              if self.debug == True:
                  BLACK = '\033[30m'
                  RED = '\033[31m'
                  GREEN = '\033[32m'
                  YELLOW = '\033[33m'
                  BLUE = '\033[34m'
                  MAGENTA = '\033[35m'
                  CYAN = '\033[36m'
                  WHITE = '\033[37m'
                  BG_BLACK = '\033[40m'
                  BG_RED = '\033[41m'
                  BG_GREEN = '\033[42m'
                  BG_YELLOW = '\033[43m'
                  BG_BLUE = '\033[44m'
                  BG_MAGENTA = '\033[45m'
                  BG_CYAN = '\033[46m'
                  BG_WHITE = '\033[47m'
                  RESET = '\033[0m'

                  """example: multiply with constant"""
                  print('\n-> every channel\'s datas:(%dx%d)' %(len(input_items[0][0]),len(input_items[0])))

                  for offset in range(len(input_items[0][0])):
                      if offset in [11,25,39,53]:
                          color = BG_BLACK+YELLOW
                          reset = RESET
                      elif offset in [0,1,2,3,4,5,59,60,61,62,63,32]:
                          color = BG_WHITE+RED
                          reset = RESET
                      else:
                          color = BG_GREEN+BLACK
                          reset = RESET
                 
                      print(color+"[%02d]->"  %(offset), end = ' ')
                      for vectorIndex in range(len(input_items[0])):
                          value = input_items[0][vectorIndex][offset]
                          if value in self.qpsk_points:
                              print('q%d' %(self.qpsk_points.index(value)), end = ' ')
                          elif value in self.bpsk_points:
                              print('b%d' %(self.bpsk_points.index(value)), end = ' ')
                          else:
                              if value.real < -1.4:
                                  print('x-', end = ' ')
                              elif value.real > 1.4:
                                  print('x+', end = ' ')
                              else:
                                  print('x0', end = ' ')
                      print(reset)
                  #print(len(input_items[0]),len(input_items[0][0]))

              return len(output_items[0])
    comment: debug for analy ofdm header
    debug: 'False'
    header_mod: header_mod
    payload_mod: payload_mod
    vectorSize: fft_len
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, length_tag_name='', debug=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                      self,
                      name='Debug Header Block',   # will show up in GRC
                      in_sig=[np.byte],
                      out_sig=[]
                      )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.length_tag_name = length_tag_name
              self.debug = debug
              

          def work(self, input_items, output_items):
              if self.debug == True:
                  """example: multiply with constant"""
                  # get all tags associated with input_items[0]
                  input_total_len = len(input_items[0])
                  input_offset = self.nitems_read(0)
                  tag_tuple = self.get_tags_in_window(0, 0, len(input_items[0]))
                  tag_num = len(tag_tuple)
                  one_tag_data_num = int(input_total_len/tag_num)

                  # loop through all 'detect' tags and store their relative offset
                  print("\none input, input_offset = %08d --> " %(input_offset))
                  for tag in tag_tuple:
                      if (pmt.to_python(tag.key) == self.length_tag_name):
                          tag_offset = tag.offset
                          tag_relative_offset = tag_offset - input_offset

                          '''
                          0-11 bits(12bits）： 数据包长度
                          12-23 bits(12bits)：标头编号（每次调用进行累加）
                          crc8 (8bits)
                          others (设置为0）
                          '''
                          print("data_lsb[%06d/%06d]=[" 
                                %(tag_relative_offset , input_total_len), end = '')
                          for index in range(one_tag_data_num):
                              print("%02X" %(input_items[0][tag_relative_offset+index]), end = ' ')
                              if index == 11: 
                                  print("len|", end = ' ')
                              elif index == 23:
                                  print("idx|", end = ' ')
                              elif index == 31:
                                  print("crc|", end = ' ')

                          print('|other]')

              return len(input_items[0])
    comment: debug for analy ofdm header
    debug: 'False'
    length_tag_name: length_tag_key
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, fft_len=64):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name="MIMO 2x2 ZF Equalizer",
                  in_sig=[(np.complex64, fft_len), (np.complex64, fft_len)], # 两路 FFT 输入
                  out_sig=[(np.complex64, fft_len), (np.complex64, fft_len)] # 两路 解耦输出
              )
              self.fft_len = fft_len

          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out0 = output_items[0]
              out1 = output_items[1]
              
              return len(out0)
    fft_len: fft_len
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class dual_stream_tag_relocator(gr.basic_block):
          def __init__(self, vlen=64, target_tag="ofdm_sync_carr_offset"):
              gr.basic_block.__init__(self,
                  name="Dual Stream Tag Relocator",
                  in_sig=[(np.complex64, vlen), (np.complex64, vlen)], # in0: 原始(带Tag), in1: 延迟(目标数据)
                  out_sig=[(np.complex64, vlen)])
              self.vlen = vlen
              self.target_tag = target_tag
              
              # 必须禁用自动传播，由我们手动将 in0 的标签挪给 out
              self.set_tag_propagation_policy(gr.TPP_DONT)

          def general_work(self, input_items, output_items):
              in0 = input_items[0] # 原始流：用来取标签
              in1 = input_items[1] # 延迟流：用来取数据
              out = output_items[0]
              
              # 取两个输入 Buffer 的交集长度，确保同步处理
              n_input = min(len(in0), len(in1))
              n_output = len(out)
              n_process = min(n_input, n_output)

              if n_process == 0:
                  return 0

              for i in range(n_process):
                  # 1. 从 in0 (原始流) 获取所有标签
                  curr_tags = self.get_tags_in_window(0, i, i + 1)
                  
                  # 2. 计算当前输出的绝对偏移量
                  abs_offset = self.nitems_written(0) + i
                  
                  # 3. 将 in0 的所有标签重新打在输出流对应的位置上
                  # 此时输出流的数据其实来自于 in1
                  for t in curr_tags:
                      # 如果你想过滤特定标签，可以在这里加 if str(t.key) == self.target_tag
                      self.add_item_tag(0, abs_offset, t.key, t.value, t.srcid)
                  
                  # 4. 核心：输出数据使用 in1 (延迟后的流)
                  out[i] = in1[i]

              # 消耗两个输入的相同长度
              self.consume(0, n_process)
              self.consume(1, n_process)
              
              return n_process
    target_tag: '"ofdm_sync_carr_offset" '
    vlen: fft_len
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, fft_len=64):
              gr.basic_block.__init__(
                  self,
                  name='Dual Path Independent Block',
                  in_sig=[(np.complex64, fft_len), (np.complex64, fft_len)], # 两路输入
                  out_sig=[(np.complex64, fft_len), (np.complex64, fft_len)] # 两路输出
              )
              self.fft_len = fft_len

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out0 = output_items[0]
              out1 = output_items[1]

              # 获取当前两路输入可用的向量个数
              n_in0 = len(in0)
              n_in1 = len(in1)
              if n_in0 != n_in1:
                  print("111111111111111111111111111", n_in0, n_in1)
              
              # 获取当前两路输出可用的空间
              n_out0 = len(out0)
              n_out1 = len(out1)

              # 能够处理的数量取决于输入和输出的最小值
              count0 = min(n_in0, n_out0)
              count1 = min(n_in1, n_out1)

              # 处理第一路数据 (仅当有数据且有空间时)
              if count0 > 0:
                  out0[:count0] = in0[:count0] # 这里替换成你的 ZF 逻辑
                  self.consume(0, count0) # 消耗第一路
              else:
                  print("zzzzzzzzzzzzzzzzzzzzzzzzzz") 
                  count0 = 0

              # 处理第二路数据 (独立判断)
              if count1 > 0:
                  out1[:count1] = in1[:count1] # 这里替换成你的 ZF 逻辑
                  self.consume(1, count1) # 消耗第二路
              else:
                  print("yyyyyyyyyyyyyyyyyyyyyyyyyyyyyyyyyyy")    
                  count1 = 0

              # 如果两路都没有处理任何数据，返回 0 告诉调度器暂时挂起
              if count0 == 0 and count1 == 0:
                  print("xxxxxxxxxxxxxxxxxxxxxxxxxxxxxxxxxxxxxx")        	
                  return 0

              # 返回每一路实际产生的样本数（注意：basic_block 的返回值通常指产生的输出样本数）
              # 在多路非对等情况下，通常需要精确管理 produce
              self.produce(0, count0)
              self.produce(1, count1)
              
              return gr.WORK_CALLED_PRODUCE
    fft_len: fft_len
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class dual_header_payload_demux(gr.basic_block):
          def __init__(self, header_len=4, payload_len=10, guard_interval=16, items_per_symbol=64, length_tag_key="frame_len"):
              gr.basic_block.__init__(
                  self,
                  name='Dual Header/Payload Demux',
                  in_sig=[np.complex64, np.complex64, np.int8],
                  out_sig=[(np.complex64, items_per_symbol), (np.complex64, items_per_symbol),
                           (np.complex64, items_per_symbol), (np.complex64, items_per_symbol)]
              )
              self.header_len = header_len
              self.payload_len = payload_len
              self.gi = guard_interval
              self.ips = items_per_symbol
              self.sym_size = self.ips + self.gi
              self.frame_size = (header_len + payload_len) * self.sym_size
              self.len_tag_key = pmt.string_to_symbol(length_tag_key)

              # 内部缓存
              self.buf0 = np.array([], dtype=np.complex64)
              self.buf1 = np.array([], dtype=np.complex64)
              self.bufT = np.array([], dtype=np.int8)

              self.OUT_HDR0, self.OUT_HDR1 = 0, 1
              self.OUT_PLD0, self.OUT_PLD1 = 2, 3

          def general_work(self, input_items, output_items):
              print(len(input_items[0]), len(input_items[1]), len(input_items[2]))
              # 1. 吸收所有输入到缓存
              self.buf0 = np.concatenate((self.buf0, input_items[0]))
              self.buf1 = np.concatenate((self.buf1, input_items[1]))
              self.bufT = np.concatenate((self.bufT, input_items[2]))
              
              n_input_actual = len(input_items[0])
              output_count_hdr = 0
              output_count_pld = 0
              
              while True:
                  # 2. 寻找触发
                  active_trig = np.where(self.bufT != 0)[0]
                  
                  if len(active_trig) == 0:
                      # 没有任何触发，清空已有的旧缓存（保留最后一点点防止触发被切断，可选）
                      self.buf0 = self.buf0[-1:] if len(self.buf0)>0 else self.buf0[0:0]
                      self.buf1 = self.buf1[-1:] if len(self.buf1)>0 else self.buf1[0:0]
                      self.bufT = self.bufT[-1:] if len(self.bufT)>0 else self.bufT[0:0]
                      break
                  
                  start_idx = active_trig[0]

                  # --- 关键修复：确保缓冲区长度足够支撑一整帧的提取 ---
                  # 最后一帧需要的结束位置索引是 start_idx + frame_size
                  if len(self.buf0) < (start_idx + self.frame_size):
                      # 数据不够，把触发点之前的东西扔了，保留触发点开始的部分，跳出等下次
                      self.buf0 = self.buf0[start_idx:]
                      self.buf1 = self.buf1[start_idx:]
                      self.bufT = self.bufT[start_idx:]
                      break
                  
                  # 3. 检查输出空间
                  if (len(output_items[self.OUT_HDR0]) < output_count_hdr + self.header_len or 
                      len(output_items[self.OUT_PLD0]) < output_count_pld + self.payload_len):
                      # 输出空间不足，保留当前触发点位置，跳出循环
                      self.buf0 = self.buf0[start_idx:]
                      self.buf1 = self.buf1[start_idx:]
                      self.bufT = self.bufT[start_idx:]
                      break

                  # 4. 提取 Header (确保 s:e 绝对合法)
                  try:
                      for i in range(self.header_len):
                          s = start_idx + i * self.sym_size + self.gi
                          e = s + self.ips
                          output_items[self.OUT_HDR0][output_count_hdr + i] = self.buf0[s:e]
                          output_items[self.OUT_HDR1][output_count_hdr + i] = self.buf1[s:e]
                      
                      # 5. 提取 Payload
                      p_base = start_idx + self.header_len * self.sym_size
                      for i in range(self.payload_len):
                          s = p_base + i * self.sym_size + self.gi
                          e = s + self.ips
                          output_items[self.OUT_PLD0][output_count_pld + i] = self.buf0[s:e]
                          output_items[self.OUT_PLD1][output_count_pld + i] = self.buf1[s:e]
                  except ValueError as e:
                      # 理论上有了上面的长度检查不会进这里，加个保险用于排查
                      print(f"[DEMUX_ERR] Slice error: start_idx={start_idx}, buf_len={len(self.buf0)}")
                      break

                  # 6. 打标与更新计数
                  self.add_item_tag(self.OUT_PLD0, self.nitems_written(self.OUT_PLD0) + output_count_pld, 
                                    self.len_tag_key, pmt.from_long(self.payload_len))

                  output_count_hdr += self.header_len
                  output_count_pld += self.payload_len
                  
                  # 7. 移除本帧数据
                  self.buf0 = self.buf0[start_idx + self.frame_size:]
                  self.buf1 = self.buf1[start_idx + self.frame_size:]
                  self.bufT = self.bufT[start_idx + self.frame_size:]
                  print(f"[DEMUX_LOG] Frame processed. Buffer remaining: {len(self.bufT)}")

              # 8. 提交结果
              if output_count_hdr > 0:
                  self.produce(self.OUT_HDR0, output_count_hdr)
                  self.produce(self.OUT_HDR1, output_count_hdr)
              if output_count_pld > 0:
                  self.produce(self.OUT_PLD0, output_count_pld)
                  self.produce(self.OUT_PLD1, output_count_pld)
              
              self.consume_each(n_input_actual)
              return gr.WORK_CALLED_PRODUCE
    guard_interval: '16'
    header_len: '4'
    items_per_symbol: '64'
    length_tag_key: '''frame_len'''
    payload_len: '10'
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class dual_header_payload_demux(gr.basic_block):
          def __init__(self, header_len=4, payload_len=10, guard_interval=16, items_per_symbol=64, length_tag_key="frame_len"):
              gr.basic_block.__init__(
                  self,
                  name='Dual Header/Payload Demux',
                  in_sig=[np.complex64, np.complex64, np.int8],
                  out_sig=[(np.complex64, items_per_symbol), (np.complex64, items_per_symbol),
                           (np.complex64, items_per_symbol), (np.complex64, items_per_symbol)]
              )
              self.header_len = header_len
              self.payload_len = payload_len
              self.gi = guard_interval
              self.ips = items_per_symbol
              self.sym_size = self.ips + self.gi
              self.frame_size = (header_len + payload_len) * self.sym_size
              self.len_tag_key = pmt.string_to_symbol(length_tag_key)

              # 内部缓存
              self.buf0 = np.array([], dtype=np.complex64)
              self.buf1 = np.array([], dtype=np.complex64)
              self.bufT = np.array([], dtype=np.int8)

              self.OUT_HDR0, self.OUT_HDR1 = 0, 1
              self.OUT_PLD0, self.OUT_PLD1 = 2, 3

          def general_work(self, input_items, output_items):
              print(len(input_items[0]), len(input_items[1]), len(input_items[2]))
              # 1. 吸收所有输入到缓存
              self.buf0 = np.concatenate((self.buf0, input_items[0]))
              self.buf1 = np.concatenate((self.buf1, input_items[1]))
              self.bufT = np.concatenate((self.bufT, input_items[2]))
              
              n_input_actual = len(input_items[0])
              output_count_hdr = 0
              output_count_pld = 0
              
              while True:
                  # 2. 寻找触发
                  active_trig = np.where(self.bufT != 0)[0]
                  
                  if len(active_trig) == 0:
                      # 没有任何触发，清空已有的旧缓存（保留最后一点点防止触发被切断，可选）
                      self.buf0 = self.buf0[-1:] if len(self.buf0)>0 else self.buf0[0:0]
                      self.buf1 = self.buf1[-1:] if len(self.buf1)>0 else self.buf1[0:0]
                      self.bufT = self.bufT[-1:] if len(self.bufT)>0 else self.bufT[0:0]
                      break
                  
                  start_idx = active_trig[0]

                  # --- 关键修复：确保缓冲区长度足够支撑一整帧的提取 ---
                  # 最后一帧需要的结束位置索引是 start_idx + frame_size
                  if len(self.buf0) < (start_idx + self.frame_size):
                      # 数据不够，把触发点之前的东西扔了，保留触发点开始的部分，跳出等下次
                      self.buf0 = self.buf0[start_idx:]
                      self.buf1 = self.buf1[start_idx:]
                      self.bufT = self.bufT[start_idx:]
                      break
                  
                  # 3. 检查输出空间
                  if (len(output_items[self.OUT_HDR0]) < output_count_hdr + self.header_len or 
                      len(output_items[self.OUT_PLD0]) < output_count_pld + self.payload_len):
                      # 输出空间不足，保留当前触发点位置，跳出循环
                      self.buf0 = self.buf0[start_idx:]
                      self.buf1 = self.buf1[start_idx:]
                      self.bufT = self.bufT[start_idx:]
                      break

                  # 4. 提取 Header (确保 s:e 绝对合法)
                  try:
                      for i in range(self.header_len):
                          s = start_idx + i * self.sym_size + self.gi
                          e = s + self.ips
                          output_items[self.OUT_HDR0][output_count_hdr + i] = self.buf0[s:e]
                          output_items[self.OUT_HDR1][output_count_hdr + i] = self.buf1[s:e]
                      
                      # 5. 提取 Payload
                      p_base = start_idx + self.header_len * self.sym_size
                      for i in range(self.payload_len):
                          s = p_base + i * self.sym_size + self.gi
                          e = s + self.ips
                          output_items[self.OUT_PLD0][output_count_pld + i] = self.buf0[s:e]
                          output_items[self.OUT_PLD1][output_count_pld + i] = self.buf1[s:e]
                  except ValueError as e:
                      # 理论上有了上面的长度检查不会进这里，加个保险用于排查
                      print(f"[DEMUX_ERR] Slice error: start_idx={start_idx}, buf_len={len(self.buf0)}")
                      break

                  # 6. 打标与更新计数
                  self.add_item_tag(self.OUT_PLD0, self.nitems_written(self.OUT_PLD0) + output_count_pld, 
                                    self.len_tag_key, pmt.from_long(self.payload_len))

                  output_count_hdr += self.header_len
                  output_count_pld += self.payload_len
                  
                  # 7. 移除本帧数据
                  self.buf0 = self.buf0[start_idx + self.frame_size:]
                  self.buf1 = self.buf1[start_idx + self.frame_size:]
                  self.bufT = self.bufT[start_idx + self.frame_size:]
                  print(f"[DEMUX_LOG] Frame processed. Buffer remaining: {len(self.bufT)}")

              # 8. 提交结果
              if output_count_hdr > 0:
                  self.produce(self.OUT_HDR0, output_count_hdr)
                  self.produce(self.OUT_HDR1, output_count_hdr)
              if output_count_pld > 0:
                  self.produce(self.OUT_PLD0, output_count_pld)
                  self.produce(self.OUT_PLD1, output_count_pld)
              
              self.consume_each(n_input_actual)
              return gr.WORK_CALLED_PRODUCE
    guard_interval: '16'
    header_len: '4'
    items_per_symbol: '64'
    length_tag_key: '''frame_len'''
    payload_len: '10'
  states: {state: disabled}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      from collections import deque

      class mimo_precision_decoder(gr.sync_block):
          def __init__(self, fft_len=64, items_per_frame=10, path_id=1, max_cache=2000, delay_syms=500, alpha=0.01):
              gr.sync_block.__init__(
                  self,
                  name=f"mimo_precision_decoder_rx{path_id}",
                  in_sig=[(np.complex64, fft_len)],
                  out_sig=[(np.complex64, fft_len)]
              )
              self.fft_len = fft_len
              self.path_id = path_id
              self.items_per_frame = items_per_frame
              self.max_cache = max_cache
              self.alpha = alpha 
              
              # 1. 内部延迟线 (FIFO) - 存储本地接收到的数据以等待远程数据对齐
              self.delay_syms = delay_syms
              self.local_fifo = deque([("None", np.zeros(fft_len, dtype=np.complex64)) for _ in range(delay_syms)])

              # 2. 消息端口
              self.message_port_register_in(pmt.intern("y_in"))
              self.message_port_register_out(pmt.intern("y_out"))
              self.message_port_register_in(pmt.intern("h_local_in"))
              self.message_port_register_in(pmt.intern("h_remote_in"))

              self.set_msg_handler(pmt.intern("y_in"), self.handle_y_msg)
              self.set_msg_handler(pmt.intern("h_local_in"), self.handle_h_local_msg)
              self.set_msg_handler(pmt.intern("h_remote_in"), self.handle_h_remote_msg)

              # 3. 缓存与平滑矩阵
              self.remote_y_buffer = {}
              self.buffer_lock = threading.Lock()
              
              # 初始化 H 矩阵分量 (默认初始化为单位阵)
              self.h11 = np.ones(fft_len, dtype=np.complex64)
              self.h12 = np.zeros(fft_len, dtype=np.complex64)
              self.h21 = np.zeros(fft_len, dtype=np.complex64)
              self.h22 = np.ones(fft_len, dtype=np.complex64)

              self.active_base_ts = "None"

          def handle_y_msg(self, msg):
              if pmt.is_pair(msg):
                  ts_str = str(pmt.to_python(pmt.car(msg)))
                  data = pmt.to_python(pmt.cdr(msg))
                  with self.buffer_lock:
                      self.remote_y_buffer[ts_str] = np.array(data, dtype=np.complex64)
                      if len(self.remote_y_buffer) > self.max_cache:
                          self.remote_y_buffer.pop(next(iter(self.remote_y_buffer)))

          def _update_h_smooth(self, h_a_new, h_b_new, is_local):
              a = self.alpha
              with self.buffer_lock:
                  # 这里的逻辑必须严格对应 C++ 端发送 h_a/h_b 的物理含义
                  if self.path_id == 1:
                      if is_local: 
                          self.h11 = (1-a)*self.h11 + a*h_a_new
                          self.h12 = (1-a)*self.h12 + a*h_b_new
                      else:       
                          self.h21 = (1-a)*self.h21 + a*h_a_new
                          self.h22 = (1-a)*self.h22 + a*h_b_new
                  else:
                      if is_local: 
                          self.h21 = (1-a)*self.h21 + a*h_a_new
                          self.h22 = (1-a)*self.h22 + a*h_b_new
                      else:       
                          self.h11 = (1-a)*self.h11 + a*h_a_new
                          self.h12 = (1-a)*self.h12 + a*h_b_new

          def handle_h_local_msg(self, msg):
              try:
                  d = pmt.to_python(pmt.cdr(msg))
                  self._update_h_smooth(np.array(d['h_a']), np.array(d['h_b']), True)
              except: pass

          def handle_h_remote_msg(self, msg):
              try:
                  d = pmt.to_python(pmt.cdr(msg))
                  self._update_h_smooth(np.array(d['h_a']), np.array(d['h_b']), False)
              except: pass

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              n_syms = len(in0)
              n_read = self.nitems_read(0)

              # 提取 rx_time 标签
              tags = self.get_tags_in_window(0, 0, n_syms)
              tag_map = { (t.offset - n_read): t.value for t in tags if pmt.to_python(t.key) == "rx_time" }

              # --- 核心改进：带正则化的求逆逻辑 ---
              with self.buffer_lock:
                  h11, h12, h21, h22 = self.h11.copy(), self.h12.copy(), self.h21.copy(), self.h22.copy()
                  det = h11 * h22 - h12 * h21
                  
                  # 正则化参数 lambda_reg。该值越小越接近纯 ZF，越大对噪声抑制越强。
                  # 建议范围: 1e-4 到 1e-2 之间
                  lambda_reg = 5e-3 
                  inv_det = np.conj(det) / (np.abs(det)**2 + lambda_reg)

              for i in range(n_syms):
                  abs_offset = n_read + i
                  if i in tag_map:
                      self.active_base_ts = str(pmt.to_python(tag_map[i]))
                  
                  sub_idx = abs_offset % self.items_per_frame
                  curr_key = f"{self.active_base_ts}_{sub_idx}"

                  # 发送本地 Y
                  if self.active_base_ts != "None":
                      msg = pmt.cons(pmt.intern(curr_key), pmt.init_c32vector(self.fft_len, in0[i].tolist()))
                      self.message_port_pub(pmt.intern("y_out"), msg)

                  self.local_fifo.append((curr_key, in0[i]))
                  old_key, old_y_local = self.local_fifo.popleft()
                  
                  with self.buffer_lock:
                      y_remote = self.remote_y_buffer.get(old_key)
                  
                  if y_remote is not None:
                      # 使用正则化后的 inv_det 进行解复用，有效减少时域毛刺
                      if self.path_id == 1:
                          out[i] = (h22 * old_y_local - h12 * y_remote) * inv_det
                      else:
                          out[i] = (-h21 * y_remote + h11 * old_y_local) * inv_det
                  else:
                      # 数据缺失时的低增益备份
                      if self.path_id == 1:
                          m = np.abs(h11) > 1e-6
                          tmp = np.zeros_like(h11); tmp[m] = 1.0 / (h11[m] + 1e-3)
                          out[i] = old_y_local * tmp * 0.1 
                      else:
                          m = np.abs(h22) > 1e-6
                          tmp = np.zeros_like(h22); tmp[m] = 1.0 / (h22[m] + 1e-3)
                          out[i] = old_y_local * tmp * 0.1

              return n_syms
    alpha: '0.05'
    delay_syms: '1000'
    fft_len: fft_len
    items_per_frame: '10'
    max_cache: '2000'
    path_id: '1'
  states: {state: disabled}
- name: epy_block_7_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import threading
      from collections import deque

      class mimo_precision_decoder(gr.sync_block):
          def __init__(self, fft_len=64, items_per_frame=10, path_id=1, max_cache=2000, delay_syms=500, alpha=0.01):
              gr.sync_block.__init__(
                  self,
                  name=f"mimo_precision_decoder_rx{path_id}",
                  in_sig=[(np.complex64, fft_len)],
                  out_sig=[(np.complex64, fft_len)]
              )
              self.fft_len = fft_len
              self.path_id = path_id
              self.items_per_frame = items_per_frame
              self.max_cache = max_cache
              self.alpha = alpha 
              
              # 1. 内部延迟线 (FIFO) - 存储本地接收到的数据以等待远程数据对齐
              self.delay_syms = delay_syms
              self.local_fifo = deque([("None", np.zeros(fft_len, dtype=np.complex64)) for _ in range(delay_syms)])

              # 2. 消息端口
              self.message_port_register_in(pmt.intern("y_in"))
              self.message_port_register_out(pmt.intern("y_out"))
              self.message_port_register_in(pmt.intern("h_local_in"))
              self.message_port_register_in(pmt.intern("h_remote_in"))

              self.set_msg_handler(pmt.intern("y_in"), self.handle_y_msg)
              self.set_msg_handler(pmt.intern("h_local_in"), self.handle_h_local_msg)
              self.set_msg_handler(pmt.intern("h_remote_in"), self.handle_h_remote_msg)

              # 3. 缓存与平滑矩阵
              self.remote_y_buffer = {}
              self.buffer_lock = threading.Lock()
              
              # 初始化 H 矩阵分量 (默认初始化为单位阵)
              self.h11 = np.ones(fft_len, dtype=np.complex64)
              self.h12 = np.zeros(fft_len, dtype=np.complex64)
              self.h21 = np.zeros(fft_len, dtype=np.complex64)
              self.h22 = np.ones(fft_len, dtype=np.complex64)

              self.active_base_ts = "None"

          def handle_y_msg(self, msg):
              if pmt.is_pair(msg):
                  ts_str = str(pmt.to_python(pmt.car(msg)))
                  data = pmt.to_python(pmt.cdr(msg))
                  with self.buffer_lock:
                      self.remote_y_buffer[ts_str] = np.array(data, dtype=np.complex64)
                      if len(self.remote_y_buffer) > self.max_cache:
                          self.remote_y_buffer.pop(next(iter(self.remote_y_buffer)))

          def _update_h_smooth(self, h_a_new, h_b_new, is_local):
              a = self.alpha
              with self.buffer_lock:
                  # 这里的逻辑必须严格对应 C++ 端发送 h_a/h_b 的物理含义
                  if self.path_id == 1:
                      if is_local: 
                          self.h11 = (1-a)*self.h11 + a*h_a_new
                          self.h12 = (1-a)*self.h12 + a*h_b_new
                      else:       
                          self.h21 = (1-a)*self.h21 + a*h_a_new
                          self.h22 = (1-a)*self.h22 + a*h_b_new
                  else:
                      if is_local: 
                          self.h21 = (1-a)*self.h21 + a*h_a_new
                          self.h22 = (1-a)*self.h22 + a*h_b_new
                      else:       
                          self.h11 = (1-a)*self.h11 + a*h_a_new
                          self.h12 = (1-a)*self.h12 + a*h_b_new

          def handle_h_local_msg(self, msg):
              try:
                  d = pmt.to_python(pmt.cdr(msg))
                  self._update_h_smooth(np.array(d['h_a']), np.array(d['h_b']), True)
              except: pass

          def handle_h_remote_msg(self, msg):
              try:
                  d = pmt.to_python(pmt.cdr(msg))
                  self._update_h_smooth(np.array(d['h_a']), np.array(d['h_b']), False)
              except: pass

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              n_syms = len(in0)
              n_read = self.nitems_read(0)

              # 提取 rx_time 标签
              tags = self.get_tags_in_window(0, 0, n_syms)
              tag_map = { (t.offset - n_read): t.value for t in tags if pmt.to_python(t.key) == "rx_time" }

              # --- 核心改进：带正则化的求逆逻辑 ---
              with self.buffer_lock:
                  h11, h12, h21, h22 = self.h11.copy(), self.h12.copy(), self.h21.copy(), self.h22.copy()
                  det = h11 * h22 - h12 * h21
                  
                  # 正则化参数 lambda_reg。该值越小越接近纯 ZF，越大对噪声抑制越强。
                  # 建议范围: 1e-4 到 1e-2 之间
                  lambda_reg = 5e-3 
                  inv_det = np.conj(det) / (np.abs(det)**2 + lambda_reg)

              for i in range(n_syms):
                  abs_offset = n_read + i
                  if i in tag_map:
                      self.active_base_ts = str(pmt.to_python(tag_map[i]))
                  
                  sub_idx = abs_offset % self.items_per_frame
                  curr_key = f"{self.active_base_ts}_{sub_idx}"

                  # 发送本地 Y
                  if self.active_base_ts != "None":
                      msg = pmt.cons(pmt.intern(curr_key), pmt.init_c32vector(self.fft_len, in0[i].tolist()))
                      self.message_port_pub(pmt.intern("y_out"), msg)

                  self.local_fifo.append((curr_key, in0[i]))
                  old_key, old_y_local = self.local_fifo.popleft()
                  
                  with self.buffer_lock:
                      y_remote = self.remote_y_buffer.get(old_key)
                  
                  if y_remote is not None:
                      # 使用正则化后的 inv_det 进行解复用，有效减少时域毛刺
                      if self.path_id == 1:
                          out[i] = (h22 * old_y_local - h12 * y_remote) * inv_det
                      else:
                          out[i] = (-h21 * y_remote + h11 * old_y_local) * inv_det
                  else:
                      # 数据缺失时的低增益备份
                      if self.path_id == 1:
                          m = np.abs(h11) > 1e-6
                          tmp = np.zeros_like(h11); tmp[m] = 1.0 / (h11[m] + 1e-3)
                          out[i] = old_y_local * tmp * 0.1 
                      else:
                          m = np.abs(h22) > 1e-6
                          tmp = np.zeros_like(h22); tmp[m] = 1.0 / (h22[m] + 1e-3)
                          out[i] = old_y_local * tmp * 0.1

              return n_syms
    alpha: '0.05'
    delay_syms: '1000'
    fft_len: fft_len
    items_per_frame: '10'
    max_cache: '2000'
    path_id: '2'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {state: disabled}
- name: fft_vxx_0_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {state: disabled}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: mimo_mimo_h_matrix_aggregator_0
  id: mimo_mimo_h_matrix_aggregator
  parameters:
    fft_len: '64'
    maxoutbuf: max_buff_size
    minoutbuf: min_buff_size
  states: {state: disabled}
- name: mimo_mimo_h_matrix_aggregator_0_0
  id: mimo_mimo_h_matrix_aggregator
  parameters:
    fft_len: '64'
    maxoutbuf: max_buff_size
    minoutbuf: min_buff_size
  states: {state: disabled}
- name: mimo_mimo_precision_decoder_0
  id: mimo_mimo_precision_decoder
  parameters:
    alpha: '0.01'
    delay_syms: '500'
    fft_len: '64'
    items_per_frame: '10'
    max_cache: '2000'
    path_id: '1'
  states: {}
- name: mimo_mimo_precision_decoder_0_0
  id: mimo_mimo_precision_decoder
  parameters:
    alpha: '0.01'
    delay_syms: '500'
    fft_len: '64'
    items_per_frame: '10'
    max_cache: '2000'
    path_id: '2'
  states: {}
- name: mimo_ofdm_chanest_vcvc_0
  id: mimo_ofdm_chanest_vcvc
  parameters:
    eq_noise_red_len: '0'
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
    sync_symbol3: sync_word2
  states: {}
- name: mimo_ofdm_chanest_vcvc_0_0
  id: mimo_ofdm_chanest_vcvc
  parameters:
    eq_noise_red_len: '0'
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
    sync_symbol3: sync_word2
  states: {}
- name: mimo_ofdm_chanest_vcvc_0_0_0
  id: mimo_ofdm_chanest_vcvc
  parameters:
    eq_noise_red_len: '0'
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
    sync_symbol3: sync_word2
  states: {state: disabled}
- name: mimo_ofdm_chanest_vcvc_0_1
  id: mimo_ofdm_chanest_vcvc
  parameters:
    eq_noise_red_len: '0'
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
    sync_symbol3: sync_word2
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (1,0,1,1)
    name: '"HEADER1 星座"'
    size: '1024'
    type: complex
    update_time: gui_update_period
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (1,1,1,1)
    name: '"PAYLOAD 1星座"'
    size: '1024'
    type: complex
    update_time: gui_update_period
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (1,3,1,1)
    name: '"PAYLOAD 2星座"'
    size: '1024'
    type: complex
    update_time: gui_update_period
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (1,2,1,1)
    name: '"HEADER2 星座"'
    size: '1024'
    type: complex
    update_time: gui_update_period
  states: {}
- name: qtgui_const_sink_x_0_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (1,1,1,1)
    name: '"HEADER2 星座"'
    size: '1024'
    type: complex
    update_time: gui_update_period
  states: {state: disabled}
- name: qtgui_const_sink_x_0_2
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (1,0,1,1)
    name: '"HEADER1 星座"'
    size: '1024'
    type: complex
    update_time: gui_update_period
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 4,1,1,1
    name: '"两路触发信号"'
    nconnections: '2'
    size: '10240'
    srate: samp_rate
    type: float
    ymax: '1.5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '10240'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (0,0,1,1)
    name: '"Pre-OFDM-header"'
    size: 48*3
    srate: '1'
    type: complex
    update_time: gui_update_period
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Pre-OFDM"'
    nconnections: '2'
    size: 448*3
    srate: '1'
    type: complex
    update_time: gui_update_period
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Tx-OFDM"'
    nconnections: '2'
    size: 448*3
    srate: '1'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 2,0,1,2
    size: '1024'
    srate: samp_rate
    type: float
    update_time: gui_update_period
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 2,2,1,2
    size: '1024'
    srate: samp_rate
    type: float
    update_time: gui_update_period
  states: {}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 4,0,1,1
    name: '"原始数据"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: gui_update_period
  states: {}
- name: qtgui_time_sink_x_2_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 2,2,1,2
    size: '1024'
    srate: samp_rate
    type: float
    update_time: gui_update_period
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 4,2,1,1
    name: '"1 路 H 矩阵匹配情况"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: gui_update_period
  states: {}
- name: qtgui_time_sink_x_2_0_2_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 4,3,1,1
    name: '"2 路 H 矩阵匹配情况"'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: gui_update_period
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: int(freq)
    center_freq1: int(freq)
    clock_source0: internal
    gain0: uhd_gain
    gain1: uhd_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: int(freq)
    center_freq1: int(freq)
    clock_source0: internal
    gain0: uhd_gain
    gain1: uhd_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: int(freq)
    center_freq1: int(freq)
    clock_source0: internal
    gain0: uhd_gain
    gain1: uhd_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: payload_stream1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: payload_stream2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM-A
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM-B
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: payload_stream2
  states: {state: disabled}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: payload_stream1
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: H1x
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Payload1 IQ
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Payload2 IQ
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: H2x
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: header_data1
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: header_data2
  states: {}
- name: virtual_sink_3_0_0
  id: virtual_sink
  parameters:
    stream_id: header_data2
  states: {state: disabled}
- name: virtual_sink_3_1
  id: virtual_sink
  parameters:
    stream_id: header_data1
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: H1x
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Payload1 IQ
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM-B
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM-A
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: Payload2 IQ
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: H2x
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: payload_stream1
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: payload_stream2
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: header_data1
  states: {}
- name: virtual_source_3_0_0
  id: virtual_source
  parameters:
    stream_id: header_data2
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [analog_const_source_x_1, '0', blocks_stream_to_tagged_stream_0_3, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_frequency_modulator_fc_0_0_1, '0', blocks_multiply_xx_0_0_1, '0']
- [analog_frequency_modulator_fc_0_2, '0', blocks_multiply_xx_0_2, '0']
- [analog_sig_source_x_0, '0', blocks_char_to_float_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_stream_to_streams_0_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_const_vxx_0_0_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_add_const_vxx_0_2, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [blocks_char_to_float_0_0_1, '0', qtgui_time_sink_x_2_0_1, '0']
- [blocks_char_to_float_1, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_char_to_float_1_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_1_0_1, '0', blocks_add_const_vxx_0_2, '0']
- [blocks_char_to_float_1_2, '0', blocks_add_const_vxx_0_0_1, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_delay_0_0_1, '0', blocks_multiply_xx_0_0_1, '1']
- [blocks_delay_0_2, '0', blocks_multiply_xx_0_2, '1']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_2_0_2, '0']
- [blocks_int_to_float_0_0, '0', qtgui_time_sink_x_2_0_2_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_int_to_float_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_int_to_float_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_tag_gate_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_tag_gate_0_0_0, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0_0, '0']
- [blocks_multiply_xx_0_0, '0', digital_header_payload_demux_0_0_0, '0']
- [blocks_multiply_xx_0_0_1, '0', epy_block_5, '1']
- [blocks_multiply_xx_0_0_1, '0', epy_block_6, '1']
- [blocks_multiply_xx_0_2, '0', epy_block_5, '0']
- [blocks_multiply_xx_0_2, '0', epy_block_6, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_crc32_bb_0_0_0, '0']
- [blocks_repack_bits_bb_0_1, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [blocks_stream_to_streams_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_streams_0_0, '1', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_crc32_bb_0_1, '0']
- [blocks_stream_to_tagged_stream_0_3, '0', blocks_tagged_stream_mux_0_1, '0']
- [blocks_tag_gate_0, '0', epy_block_6, '2']
- [blocks_tag_gate_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_tag_gate_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_tag_gate_0_0_0, '0', qtgui_time_sink_x_1_0_0, '1']
- [blocks_tag_gate_0_0_0, '0', uhd_usrp_sink_0, '1']
- [blocks_tagged_stream_mux_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [blocks_tagged_stream_mux_0_1, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_tagged_stream_mux_0_1, '0', virtual_sink_0_0_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_tagged_stream_mux_0_1, '1']
- [digital_chunks_to_symbols_xx_0_0_0, '0', qtgui_time_sink_x_1_0, '1']
- [digital_chunks_to_symbols_xx_0_0_0, '0', virtual_sink_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_packet_headerparser_b_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_packet_headerparser_b_0_0_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', digital_packet_headerparser_b_0_1, '0']
- [digital_constellation_decoder_cb_1, '0', blocks_repack_bits_bb_0_0, '0']
- [digital_constellation_decoder_cb_1_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', virtual_sink_1_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', virtual_sink_1_0_0, '0']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_packet_headergenerator_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_tag_debug_1, '0']
- [digital_crc32_bb_0_0_0, '0', blocks_tag_debug_1_1, '0']
- [digital_crc32_bb_0_1, '0', blocks_repack_bits_bb_0_1, '0']
- [digital_header_payload_demux_0_0, '0', fft_vxx_0_0, '0']
- [digital_header_payload_demux_0_0, '1', virtual_sink_0, '0']
- [digital_header_payload_demux_0_0_0, '0', fft_vxx_0_0_0, '0']
- [digital_header_payload_demux_0_0_0, '1', virtual_sink_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', epy_block_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0_0, '0', epy_block_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_header, '0']
- [digital_ofdm_frame_equalizer_vcvc_0_0, '0', digital_ofdm_serializer_vcc_header_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0_0_0, '0', digital_ofdm_serializer_vcc_header_0_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0_1, '0', digital_ofdm_serializer_vcc_header_1, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', digital_ofdm_serializer_vcc_payload, '0']
- [digital_ofdm_frame_equalizer_vcvc_1_0, '0', digital_ofdm_serializer_vcc_payload_0, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_constellation_decoder_cb_0, '0']
- [digital_ofdm_serializer_vcc_header, '0', qtgui_const_sink_x_0, '0']
- [digital_ofdm_serializer_vcc_header_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_ofdm_serializer_vcc_header_0, '0', qtgui_const_sink_x_0_1, '0']
- [digital_ofdm_serializer_vcc_header_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [digital_ofdm_serializer_vcc_header_0_0, '0', qtgui_const_sink_x_0_1_0, '0']
- [digital_ofdm_serializer_vcc_header_1, '0', digital_constellation_decoder_cb_0_1, '0']
- [digital_ofdm_serializer_vcc_header_1, '0', qtgui_const_sink_x_0_2, '0']
- [digital_ofdm_serializer_vcc_payload, '0', digital_costas_loop_cc_0_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', digital_pfb_clock_sync_xxx_0_1, '0']
- [digital_ofdm_serializer_vcc_payload, '0', qtgui_const_sink_x_0_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', virtual_sink_1_0, '0']
- [digital_ofdm_serializer_vcc_payload_0, '0', digital_costas_loop_cc_0_0_0, '0']
- [digital_ofdm_serializer_vcc_payload_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [digital_ofdm_serializer_vcc_payload_0, '0', virtual_sink_1_0_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', blocks_char_to_float_1, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0_0, '1']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0_0_0, '1']
- [digital_ofdm_sync_sc_cfb_0_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [digital_ofdm_sync_sc_cfb_0_0, '1', blocks_char_to_float_1_0, '0']
- [digital_ofdm_sync_sc_cfb_0_0_1, '0', analog_frequency_modulator_fc_0_0_1, '0']
- [digital_ofdm_sync_sc_cfb_0_0_1, '1', blocks_char_to_float_1_0_1, '0']
- [digital_ofdm_sync_sc_cfb_0_2, '0', analog_frequency_modulator_fc_0_2, '0']
- [digital_ofdm_sync_sc_cfb_0_2, '1', blocks_char_to_float_1_2, '0']
- [digital_ofdm_sync_sc_cfb_0_2, '1', blocks_tag_gate_0, '0']
- [digital_ofdm_sync_sc_cfb_0_2, '1', epy_block_5, '2']
- [digital_packet_headergenerator_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_packet_headergenerator_bb_0, '0', epy_block_1, '0']
- [digital_packet_headerparser_b_0, header_data, blocks_message_debug_0, print]
- [digital_packet_headerparser_b_0, header_data, virtual_sink_3, '0']
- [digital_packet_headerparser_b_0_0, header_data, blocks_message_debug_0_0, print]
- [digital_packet_headerparser_b_0_0, header_data, virtual_sink_3_0, '0']
- [digital_packet_headerparser_b_0_0_0, header_data, blocks_message_debug_0_0_0, print]
- [digital_packet_headerparser_b_0_0_0, header_data, virtual_sink_3_0_0, '0']
- [digital_packet_headerparser_b_0_1, header_data, blocks_message_debug_0_1, print]
- [digital_packet_headerparser_b_0_1, header_data, virtual_sink_3_1, '0']
- [digital_pfb_clock_sync_xxx_0_1, '0', digital_costas_loop_cc_0_0, '0']
- [epy_block_0, '0', fft_vxx_0, '0']
- [epy_block_0_0, '0', fft_vxx_0_1, '0']
- [epy_block_4, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [epy_block_4, '1', digital_ofdm_frame_equalizer_vcvc_1_0, '0']
- [epy_block_5, '0', blocks_null_sink_1, '0']
- [epy_block_5, '0', fft_vxx_0_0_1, '0']
- [epy_block_5, '1', blocks_null_sink_1, '1']
- [epy_block_5, '1', fft_vxx_0_0_0_0, '0']
- [epy_block_5, '2', blocks_null_sink_1, '2']
- [epy_block_5, '2', virtual_sink_0_1, '0']
- [epy_block_5, '3', blocks_null_sink_1, '3']
- [epy_block_5, '3', virtual_sink_0_0_1, '0']
- [epy_block_6, '0', blocks_null_sink_1_0, '0']
- [epy_block_6, '1', blocks_null_sink_1_0, '1']
- [epy_block_6, '2', blocks_null_sink_1_0, '2']
- [epy_block_6, '3', blocks_null_sink_1_0, '3']
- [epy_block_7, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [epy_block_7, '0', digital_ofdm_serializer_vcc_payload, '0']
- [epy_block_7, y_out, epy_block_7_0, y_in]
- [epy_block_7_0, '0', digital_ofdm_frame_equalizer_vcvc_1_0, '0']
- [epy_block_7_0, '0', digital_ofdm_serializer_vcc_payload_0, '0']
- [epy_block_7_0, y_out, epy_block_7, y_in]
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', mimo_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_0_0_0, '0', mimo_ofdm_chanest_vcvc_0_0, '0']
- [fft_vxx_0_0_0_0, '0', mimo_ofdm_chanest_vcvc_0_0_0, '0']
- [fft_vxx_0_0_1, '0', mimo_ofdm_chanest_vcvc_0_1, '0']
- [fft_vxx_0_1, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [fft_vxx_1, '0', epy_block_4, '0']
- [fft_vxx_1, '0', epy_block_7, '0']
- [fft_vxx_1, '0', mimo_mimo_precision_decoder_0, '0']
- [fft_vxx_1_0, '0', epy_block_4, '1']
- [fft_vxx_1_0, '0', epy_block_7_0, '0']
- [fft_vxx_1_0, '0', mimo_mimo_precision_decoder_0_0, '0']
- [mimo_mimo_h_matrix_aggregator_0, '0', blocks_tag_debug_1_0_0, '0']
- [mimo_mimo_h_matrix_aggregator_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [mimo_mimo_h_matrix_aggregator_0, '1', blocks_tag_debug_1_0, '0']
- [mimo_mimo_h_matrix_aggregator_0, '1', digital_ofdm_frame_equalizer_vcvc_0_0, '0']
- [mimo_mimo_h_matrix_aggregator_0_0, '0', blocks_tag_debug_1_0_0_1, '0']
- [mimo_mimo_h_matrix_aggregator_0_0, '0', digital_ofdm_frame_equalizer_vcvc_0_1, '0']
- [mimo_mimo_h_matrix_aggregator_0_0, '1', blocks_tag_debug_1_0_1, '0']
- [mimo_mimo_h_matrix_aggregator_0_0, '1', digital_ofdm_frame_equalizer_vcvc_0_0_0, '0']
- [mimo_mimo_precision_decoder_0, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [mimo_mimo_precision_decoder_0, '0', digital_ofdm_serializer_vcc_payload, '0']
- [mimo_mimo_precision_decoder_0, '1', blocks_vector_to_stream_0, '0']
- [mimo_mimo_precision_decoder_0, y_out, mimo_mimo_precision_decoder_0_0, y_in]
- [mimo_mimo_precision_decoder_0_0, '0', digital_ofdm_frame_equalizer_vcvc_1_0, '0']
- [mimo_mimo_precision_decoder_0_0, '0', digital_ofdm_serializer_vcc_payload_0, '0']
- [mimo_mimo_precision_decoder_0_0, '1', blocks_vector_to_stream_0_0, '0']
- [mimo_mimo_precision_decoder_0_0, y_out, mimo_mimo_precision_decoder_0, y_in]
- [mimo_ofdm_chanest_vcvc_0, '0', blocks_tag_debug_1_0_0_0, '0']
- [mimo_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [mimo_ofdm_chanest_vcvc_0, '0', mimo_mimo_h_matrix_aggregator_0, '0']
- [mimo_ofdm_chanest_vcvc_0, h_out, virtual_sink_1, '0']
- [mimo_ofdm_chanest_vcvc_0_0, '0', blocks_tag_debug_1_0_0_0_1, '0']
- [mimo_ofdm_chanest_vcvc_0_0, '0', digital_ofdm_frame_equalizer_vcvc_0_0, '0']
- [mimo_ofdm_chanest_vcvc_0_0, '0', mimo_mimo_h_matrix_aggregator_0, '1']
- [mimo_ofdm_chanest_vcvc_0_0, h_out, virtual_sink_1_1, '0']
- [mimo_ofdm_chanest_vcvc_0_0_0, '0', digital_ofdm_frame_equalizer_vcvc_0_0_0, '0']
- [mimo_ofdm_chanest_vcvc_0_0_0, '0', mimo_mimo_h_matrix_aggregator_0_0, '1']
- [mimo_ofdm_chanest_vcvc_0_1, '0', blocks_tag_debug_1_0_0_0_0, '0']
- [mimo_ofdm_chanest_vcvc_0_1, '0', digital_ofdm_frame_equalizer_vcvc_0_1, '0']
- [mimo_ofdm_chanest_vcvc_0_1, '0', mimo_mimo_h_matrix_aggregator_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0_0, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_delay_0_0, '0']
- [uhd_usrp_source_0_0, '1', digital_ofdm_sync_sc_cfb_0_0, '0']
- [uhd_usrp_source_0_0_1, '0', blocks_delay_0_2, '0']
- [uhd_usrp_source_0_0_1, '0', digital_ofdm_sync_sc_cfb_0_2, '0']
- [uhd_usrp_source_0_0_1, '1', blocks_delay_0_0_1, '0']
- [uhd_usrp_source_0_0_1, '1', digital_ofdm_sync_sc_cfb_0_0_1, '0']
- [virtual_source_0, '0', epy_block_7, h_local_in]
- [virtual_source_0, '0', epy_block_7_0, h_remote_in]
- [virtual_source_0, '0', mimo_mimo_precision_decoder_0, h_local_in]
- [virtual_source_0, '0', mimo_mimo_precision_decoder_0_0, h_remote_in]
- [virtual_source_0_0, '0', digital_constellation_decoder_cb_1, '0']
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0_0, '0']
- [virtual_source_0_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_0_0_1, '0', digital_constellation_decoder_cb_1_0, '0']
- [virtual_source_1, '0', epy_block_7, h_remote_in]
- [virtual_source_1, '0', epy_block_7_0, h_local_in]
- [virtual_source_1, '0', mimo_mimo_precision_decoder_0, h_remote_in]
- [virtual_source_1, '0', mimo_mimo_precision_decoder_0_0, h_local_in]
- [virtual_source_1_0, '0', blocks_null_sink_0, '0']
- [virtual_source_1_0, '0', blocks_tag_debug_1_2, '0']
- [virtual_source_1_0, '0', fft_vxx_1, '0']
- [virtual_source_1_0_0, '0', blocks_null_sink_0_0, '0']
- [virtual_source_1_0_0, '0', fft_vxx_1_0, '0']
- [virtual_source_3_0, '0', digital_header_payload_demux_0_0, header_data]
- [virtual_source_3_0_0, '0', digital_header_payload_demux_0_0_0, header_data]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
